# Altium schematic sheet connectors.SchDoc
size A4

## Parts
J1  KAWEEI CHDMI-AMSS-01-D  [KAWEEI_CHDMI_AMSS-01-D]
J2  KAWEEI CHDMI-AMSS-01-D  [KAWEEI_CHDMI_AMSS-01-D]
R1  820, 1%  [CAPC0603X03L]
R2  820, 1%  [CAPC0603X03L]
R3  820, 1%  [CAPC0603X03L]
R4  820, 1%  [CAPC0603X03L]

## Nets
GND: J1.0(GND) J1.2 J1.5 J1.8 J1.11 J1.17 J2.0(GND) J2.2 J2.5 J2.8 J2.11 J2.17
CEC: J1.13 J2.13
CLK_N: J1.12 J2.10 R4.2
CLK_P: J1.10 J2.12 R4.1
DDC_SCL: J1.15 J2.15
DDC_SDA: J1.16 J2.16
HPD: J1.19 J2.19
P5V: J1.18 J2.18
TMDS0_N: J1.9 J2.7 R3.1
TMDS0_P: J1.7 J2.9 R3.2
TMDS1_N: J1.6 J2.4 R2.2
TMDS1_P: J1.4 J2.6 R2.1
TMDS2_N: J1.3 J2.1 R1.1
TMDS2_P: J1.1 J2.3 R1.2

Not connected (* = marked no-connect by the designer): J1 14; J2 14

## Layout directives
differential pair: CLK_N, CLK_P, TMDS0_N, TMDS0_P, TMDS1_N, TMDS1_P, TMDS2_N, TMDS2_P
net class HDMI_TX: CLK_N, CLK_P, TMDS0_N, TMDS0_P, TMDS1_N, TMDS1_P, TMDS2_N, TMDS2_P

## Notes on the sheet
- (near R2) note: all pairs swapped
- (near R2) swap it on the FPGA!

## Library data of the parts
J1 J2 = Header 19: Molex HDMI connector, Type A; MYPN: J-CHDMI-AMSS-01-D
R1-R4 = Res1: Resistor; VENDOR: ANY; MYPN: R-821-1P-1_16W-0201
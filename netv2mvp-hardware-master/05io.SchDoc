# Altium schematic sheet 05io.SchDoc
size C

## Parts
C10H  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C11H  10uF, 6.3V, X5R  [CAPC1608N]
C12H  0.1uF, 6.3V, X5R  [CAPC0603X03L]
D10H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D11H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D12H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D13H  ESD5Z5.0T1G  [SOD-523]
D14H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D15H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D16H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D17H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D18H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D19H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D20H  ESD5Z5.0T1G  [SOD-523]
D21H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D22H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
D23H  RCLAMP0524P  [SEMTECH_SLP2510P8]  (value not drawn)
F10H  PRG21BB150MB1RK  [RESC2012N]
F11H  PRG21BB150MB1RK  [RESC2012N]
J10H  AUK HDM19SW-4-L2-1R3HHCN  [MOLEX_47151-0001]
J11H  AUK HDM19SW-4-L2-1R3HHCN  [MOLEX_47151-0001]
J12H  AUK HDM19SW-4-L2-1R3HHCN  [MOLEX_47151-0001]
P10H  HDMI Type D  [MOLEX_0467651301]
P11H  Header 11X2  [HDR2X11]
P12H  FCI 10103594-0001LF  [USB_MICRO_B_SMT]
P13H  PCIeX4-GF-2D-1000-1K-O64  [PCIeX4-GF-2D-1000-1K-O64]  (no BOM)
Q10H  BSS84  [SOT23-3N]
Q11H  FDV301N  [SOT23-3N]
Q12H  FDV301N  [SOT23-3N]
Q13H  BSS84  [SOT23-3N]
Q14H  FDV301N  [SOT23-3N]
Q15H  FDV301N  [SOT23-3N]
Q16H  BSS138  [SOT23-3N]
Q17H  BSS138  [SOT23-3N]
Q18H  BSS138  [SOT23-3N]
R10H  100k, 1%  [RESC1005N]
R11H  47/RP  [PANASONIC_EXB24V]
R12H  47/RP  [PANASONIC_EXB24V]
R13H  47/RP  [PANASONIC_EXB24V]
R14H  47/RP  [PANASONIC_EXB24V]
R15H  39, 1%  [RESC1005N]
R16H  1k, 1%  [RESC1005N]
R17H  1k, 1%  [RESC1005N]
R18H  39, 1%  [RESC1005N]
R19H  47/RP  [PANASONIC_EXB24V]
R20H  1k, 1%  [RESC1005N]
R21H  47/RP  [PANASONIC_EXB24V]
R22H  47/RP  [PANASONIC_EXB24V]
R23H  1.5k, 1%  [RESC1005N]
R24H  1.5k, 1% (DNP)  [RESC1005N]
R25H  47/RP  [PANASONIC_EXB24V]
R26H  39, 1%  [RESC1005N]
R27H  1k, 1%  [RESC1005N]
R28H  39, 1%  [RESC1005N]
R29H  1k, 1%  [RESC1005N]
R30H  39, 1%  [RESC1005N]
R31H  1k, 1%  [RESC1005N]
R32H  39, 1%  [RESC1005N]
R33H  10k, 1%  [RESC1005N]
R34H  1k, 1%  [RESC1005N]
R35H  1.8k, 1%  [RESC1005N]
R36H  1.8k, 1%  [RESC1005N]
R37H  DNP  [RESC1005N]
R38H  0 ohm  [RESC1005N]
R39H  DNP  [RESC1005N]
R40H  100k, 1%  [RESC1005N]
R41H  1.8k, 1%  [RESC1005N]
R42H  1.8k, 1%  [RESC1005N]
R43H  1.8k, 1%  [RESC1005N]
R44H  1.8k, 1%  [RESC1005N]
TP10H  test point (DNP)  [TP_2MM_SQ]
TP11H  test point (DNP)  [TP_2MM_SQ]
TP12H  test point (DNP)  [TP_2MM_SQ]
TP13H  test point (DNP)  [TP_2MM_SQ]
U10H  74VHC04MTC  [TSOP65P640-14AN]  (parts A,B,C,D,E,F of 6)

## Nets
GND: C10H.2 C11H.2 C12H.2 D10H.3(GND1) D11H.3(GND1) D12H.3(GND1) D13H.2(A) D14H.3(GND1) D15H.3(GND1) D16H.3(GND1) D17H.3(GND1) D18H.3(GND1) D19H.3(GND1) D20H.2(A) D21H.3(GND1) D22H.3(GND1) D23H.3(GND1) J10H.0(GND) J10H.2 J10H.5 J10H.8 J10H.11 J10H.17 J11H.0(GND) J11H.2 J11H.5 J11H.8 J11H.11 J11H.17 J12H.0(GND) J12H.2 J12H.5 J12H.8 J12H.11 J12H.17 P10H.0(SHELL) P10H.4(Shield) P10H.7(Shield) P10H.10(Shield) P10H.13(Shield) P10H.16(GND) P11H.11 P11H.12 P11H.21 P11H.22 P12H.0(PAD) P12H.5(GND) P13H.A4 P13H.A12 P13H.A15 P13H.A18 P13H.A20 P13H.A23 P13H.A24 P13H.A27 P13H.A28 P13H.A31 P13H.B4 P13H.B7 P13H.B13 P13H.B16 P13H.B18 P13H.B21 P13H.B22 P13H.B25 P13H.B26 P13H.B29 P13H.B32 Q11H.2(S) Q12H.2(S) Q14H.2(S) Q15H.2(S) R10H.1 R17H.2 R20H.2 R31H.2 R33H.2 R34H.2 R39H.2 R40H.1 TP11H.1 TP13H.1 U10H.7(GND)
P3.3V: C10H.1 C12H.1 P11H.1 P11H.2 Q16H.1(G) Q17H.1(G) Q18H.1(G) R11H.1(R1) R11H.2(R2) R12H.3(R22) R12H.4(R12) R13H.1(R1) R13H.2(R2) R14H.3(R22) R14H.4(R12) R19H.3(R22) R19H.4(R12) R21H.1(R1) R21H.2(R2) R22H.1(R1) R22H.2(R2) R23H.1 R24H.1 R25H.3(R22) R25H.4(R12) R36H.1 R42H.1 R44H.1 U10H.14(P3.3V)
P5.0V: F10H.1 F11H.1 Q10H.2(S) R16H.1 R41H.1 R43H.1
P12V: P13H.A2 P13H.A3 P13H.B1 P13H.B2 P13H.B3
VUSB: C11H.1 P12H.1(VBUS)
CEC: D10H.1(IO1A) D10H.10(IO1B) D14H.1(IO1A) D14H.10(IO1B) J10H.13 J11H.13 R15H.1
CEC_R: R15H.2
DDC_SCL: D10H.2(IO2A) D10H.9(IO2B) D14H.2(IO2A) D14H.9(IO2B) J10H.15 J11H.15 U10H.5(A)
DDC_SCL_LV_N: U10H.6(~{O})
DDC_SDA: D10H.4(IO3A) D10H.7(IO3B) D14H.4(IO3A) D14H.7(IO3B) J10H.16 J11H.16 Q10H.3(D) R18H.2 U10H.13(A)
DDC_SDA_LV_N: U10H.12(~{O})
DDC_SDA_PD: Q12H.1(G) R20H.1
DDC_SDA_PU: Q11H.1(G) R17H.1
FUSB_N: R23H.2 R28H.1
FUSB_P: R24H.2 R30H.1
FUSBD_N: P12H.2(D-) R28H.2
FUSBD_P: P12H.3(D+) R30H.2
HAX_0: P11H.8
HAX_1: P11H.10
HAX_2: P11H.3
HAX_3: P11H.5
HAX_4: P11H.7
HAX_5: P11H.4
HAX_6: P11H.6
HAX_7: P11H.9
HAX_8: P11H.16
HAX_9: P11H.13
HAX_10: P11H.19
HAX_11: P11H.17
HAX_12: P11H.20
HAX_13: P11H.18
HAX_14: P11H.14
HAX_15: P11H.15
HAX_CLK_N: TP12H.1
HAX_CLK_P: TP10H.1
HDMI_HPD: D10H.5(IO4A) D10H.6(IO4B) D14H.5(IO4A) D14H.6(IO4B) J10H.19 J11H.19 Q15H.3(D) R10H.2 R32H.1 U10H.3(A)
HDMI_HPD_LL_N: U10H.4(~{O})
OV0_CEC: D17H.1(IO1A) D17H.10(IO1B) J12H.13 R26H.1
OV0_CEC_R: R26H.2
OV0_DDC_SCL: D17H.2(IO2A) D17H.9(IO2B) J12H.15 U10H.11(A)
OV0_DDC_SCL_LV: U10H.10(~{O})
OV0_DDC_SDA: D17H.4(IO3A) D17H.7(IO3B) J12H.16 Q16H.3(D) R35H.2
OV0_DDC_SDA_LV: Q16H.2(S) R36H.2
OV0_HDMI_HPD: D17H.5(IO4A) D17H.6(IO4B) J12H.19 R29H.1 R33H.1 U10H.9(A)
OV0_HDMI_HPD_LV: U10H.8(~{O})
OV0_P5V: J12H.18 R29H.2 R35H.1
OV0_TMDS0_N: D18H.4(IO3A) D18H.7(IO3B) J12H.9 R22H.3(R22)
OV0_TMDS0_P: D18H.5(IO4A) D18H.6(IO4B) J12H.7 R22H.4(R12)
OV0_TMDS1_N: D19H.1(IO1A) D19H.10(IO1B) J12H.6 R21H.3(R22)
OV0_TMDS1_P: D19H.2(IO2A) D19H.9(IO2B) J12H.4 R21H.4(R12)
OV0_TMDS2_N: D19H.4(IO3A) D19H.7(IO3B) J12H.3 R19H.2(R2)
OV0_TMDS2_P: D19H.5(IO4A) D19H.6(IO4B) J12H.1 R19H.1(R1)
OV0_TMDS3_N: D18H.1(IO1A) D18H.10(IO1B) J12H.12 R25H.2(R2)
OV0_TMDS3_P: D18H.2(IO2A) D18H.9(IO2B) J12H.10 R25H.1(R1)
PER0_N: P13H.A17
PER0_P: P13H.A16
PER1_N: P13H.A22
PER1_P: P13H.A21
PER2_N: P13H.A26
PER2_P: P13H.A25
PER3_N: P13H.A30
PER3_P: P13H.A29
PERST#: P13H.A11
PET0_N: P13H.B15
PET0_P: P13H.B14
PET1_N: P13H.B20
PET1_P: P13H.B19
PET2_N: P13H.B24
PET2_P: P13H.B23
PET3_N: P13H.B28
PET3_P: P13H.B27
PRSNT: P13H.A1 R37H.2 R38H.2
PRSNT_X1: P13H.B17 R37H.1
PRSNT_X4: P13H.B31 R38H.1
REFCLK_N: P13H.A14
REFCLK_P: P13H.A13
RX0_FORCEPLUG: Q14H.1(G) R31H.1
RX0_FORCEUNPLUG: Q15H.1(G) R34H.1
RX0_TMDS0_N: D15H.4(IO3A) D15H.7(IO3B) J11H.9 R13H.3(R22)
RX0_TMDS0_P: D15H.5(IO4A) D15H.6(IO4B) J11H.7 R13H.4(R12)
RX0_TMDS1_N: D16H.1(IO1A) D16H.10(IO1B) J11H.6 R12H.2(R2)
RX0_TMDS1_P: D16H.2(IO2A) D16H.9(IO2B) J11H.4 R12H.1(R1)
RX0_TMDS2_N: D16H.4(IO3A) D16H.7(IO3B) J11H.3 R11H.3(R22)
RX0_TMDS2_P: D16H.5(IO4A) D16H.6(IO4B) J11H.1 R11H.4(R12)
RX0_TMDS3_N: D15H.1(IO1A) D15H.10(IO1B) J11H.12 R14H.2(R2)
RX0_TMDS3_P: D15H.2(IO2A) D15H.9(IO2B) J11H.10 R14H.1(R1)
SMCLK: P13H.B5
SMDAT: P13H.B6
TX0_TMDS0_N: D11H.4(IO3A) D11H.7(IO3B) J10H.9
TX0_TMDS0_P: D11H.5(IO4A) D11H.6(IO4B) J10H.7
TX0_TMDS1_N: D12H.1(IO1A) D12H.10(IO1B) J10H.6
TX0_TMDS1_P: D12H.2(IO2A) D12H.9(IO2B) J10H.4
TX0_TMDS2_N: D12H.4(IO3A) D12H.7(IO3B) J10H.3
TX0_TMDS2_P: D12H.5(IO4A) D12H.6(IO4B) J10H.1
TX0_TMDS3_N: D11H.1(IO1A) D11H.10(IO1B) J10H.12
TX0_TMDS3_P: D11H.2(IO2A) D11H.9(IO2B) J10H.10
TX1_CEC: D21H.1(IO1A) D21H.10(IO1B) P10H.15(CEC)
TX1_CLK_N: D22H.1(IO1A) D22H.10(IO1B) P10H.14(TMDS_CK-)
TX1_CLK_P: D22H.2(IO2A) D22H.9(IO2B) P10H.12(TMDS_CK+)
TX1_HDMI_5V: D20H.1(K) F11H.2 P10H.19(+5V)
TX1_HPD: D21H.5(IO4A) D21H.6(IO4B) P10H.1(HPD) R40H.2 U10H.1(A)
TX1_HPD_LL: U10H.2(~{O})
TX1_SCL: D21H.2(IO2A) D21H.9(IO2B) P10H.17(SCL) Q18H.3(D) R43H.2
TX1_SCL_LV: Q18H.2(S) R44H.2
TX1_SDA: D21H.4(IO3A) D21H.7(IO3B) P10H.18(SDA) Q17H.3(D) R41H.2
TX1_SDA_LV: Q17H.2(S) R42H.2
TX1_TMDS0_N: D22H.4(IO3A) D22H.7(IO3B) P10H.11(TMDS0-)
TX1_TMDS0_P: D22H.5(IO4A) D22H.6(IO4B) P10H.9(TMDS0+)
TX1_TMDS1_N: D23H.1(IO1A) D23H.10(IO1B) P10H.8(TMDS1-)
TX1_TMDS1_P: D23H.2(IO2A) D23H.9(IO2B) P10H.6(TMDS1+)
TX1_TMDS2_N: D23H.4(IO3A) D23H.7(IO3B) P10H.5(TMDS2-)
TX1_TMDS2_P: D23H.5(IO4A) D23H.6(IO4B) P10H.3(TMDS2+)
TX_HDMI_5V: D13H.1(K) F10H.2 J10H.18 Q13H.2(S) R27H.1
WAKE#: P13H.B11
NetP12H_4: P12H.4(ID) R39H.1
NetQ10H_1: Q10H.1(G) Q11H.3(D) R16H.2
NetQ12H_3: Q12H.3(D) R18H.1
NetQ13H_1: Q13H.1(G) Q14H.3(D) R27H.2
NetQ13H_3: Q13H.3(D) R32H.2

Not connected (* = marked no-connect by the designer): J10H 14; J11H 14 18; J12H 14; P10H 2(Utility)*; P13H A5 A6 A7 A8 A9 A10 A19* A32 B8 B9 B10 B12 B30

## Layout directives
differential pair: FUSB_N, FUSB_P, FUSBD_N, FUSBD_P, OV0_TMDS0_N, OV0_TMDS0_P, OV0_TMDS1_N, OV0_TMDS1_P, OV0_TMDS2_N, OV0_TMDS2_P, OV0_TMDS3_N, OV0_TMDS3_P, RX0_TMDS0_N, RX0_TMDS0_P, RX0_TMDS1_N, RX0_TMDS1_P, RX0_TMDS2_N, RX0_TMDS2_P, RX0_TMDS3_N, RX0_TMDS3_P, TX0_TMDS0_N, TX0_TMDS0_P, TX0_TMDS1_N, TX0_TMDS1_P, TX0_TMDS2_N, TX0_TMDS2_P, TX0_TMDS3_N, TX0_TMDS3_P, TX1_CLK_N, TX1_CLK_P, TX1_TMDS0_N, TX1_TMDS0_P, TX1_TMDS1_N, TX1_TMDS1_P, TX1_TMDS2_N, TX1_TMDS2_P
net class HDMI_TX: TX0_TMDS0_N, TX0_TMDS0_P, TX0_TMDS1_N, TX0_TMDS1_P, TX0_TMDS2_N, TX0_TMDS2_P, TX0_TMDS3_N, TX0_TMDS3_P, TX1_CLK_N, TX1_CLK_P, TX1_TMDS0_N, TX1_TMDS0_P, TX1_TMDS1_N, TX1_TMDS1_P, TX1_TMDS2_N, TX1_TMDS2_P
rule Matched Net Lengths [Tolerance = 40mil]: TX0_TMDS2_P, TX0_TMDS3_N
rule Matched Net Lengths [Tolerance = 2mil]: OV0_TMDS2_P, RX0_TMDS2_P, TX0_TMDS2_P, TX0_TMDS3_N
net class HDMI_CNR: OV0_TMDS0_N, OV0_TMDS0_P, OV0_TMDS1_N, OV0_TMDS1_P, OV0_TMDS2_N, OV0_TMDS2_P, OV0_TMDS3_N, OV0_TMDS3_P, RX0_TMDS0_N, RX0_TMDS0_P, RX0_TMDS1_N, RX0_TMDS1_P, RX0_TMDS2_N, RX0_TMDS2_P, RX0_TMDS3_N, RX0_TMDS3_P
net class USB_NETS: FUSB_N, FUSB_P, FUSBD_N, FUSBD_P

## Notes on the sheet
- (near P10H) HDMI-D connector - source
- (near D10H) HDMI ESD
- HDMI EMI
- HDMI-A connector - source
- LAYOUT: ROUTE HDMI_TX* AND TX* SHORT, STRAIGHT,
- 100 OHM DIFFERENTIAL IMPEDANCE.
- AND WITHOUT VIAS.  ROUTE PAIRS WITH
- (near D12H) LAYOUT: PLACE ESD IN SERIES TO ELIMINATE STUBS
- RUN TRACES STRAIGHT UNDER ESD WITHOUT VIAS
- HDMI +5V fuse
- Provide independent +5V
- So we can do Rx-less transmit
- (near F10H) INFO: 40MA hold
- (near F10H) 140MA TRIP
- HDMI-A connector - sink
- (near D14H) HDMI ESD
- RSVD
- (near U10H) Sense the HPD state of Rx/Tx passthru
- (near R14H) CEC is 3.3V-level
- HPD here is "pass through" with overrides
- (near J11H) We don't use +5V as it should be handled by downstream Rx
- (near D16H) LAYOUT: PLACE ESD IN SERIES TO ELIMINATE STUBS
- (near D17H) HDMI ESD
- Use discrete FETs so we can swap in beefy parts if necessary
- Overrides for DDC on Rx/Tx passthru
- CEC is 3.3V-level
- HPD here is "sense-only" and defaults to plugged in
- so any TX plugged here will start auto-talking
- (near D19H) LAYOUT: PLACE ESD IN SERIES TO ELIMINATE STUBS
- (near R35H) This is just regular level shifter as we should be DDC target only (not passthru) for this port
- can't use 2N7002 here b/c Vth is too high

## Library data of the parts
C10H C12H = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A104KQ3NNNC; VENDOR: Samsung; MYPN: C-104-6p3-X5R-0201
C11H = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL10A106MQ8NNNC; VENDOR: Samsung; MYPN: C-106-6.3-X5R-0603
D10H D11H D12H D14H D15H D16H D17H D18H D19H D21H D22H D23H = RCLAMP0524P: PART_NUMBER: V00004-001; MPN: RCLAMP0524PATCT; CDS_LMAN_SYM_OUTLINE: -175,225,175,-175; MATERIAL: IC; PACK_TYPE: SLP1610P4; PATH: I24; OriginalSymbolOrigin: (-175,225); LOCATION: D8; XY: (-2475,4175); VER: 1; ROT: 0; PHYS_PAGE: 10; DRAWING: @BROWNSTONE_LIB.BROWNSTONE(SCH_1):PAGE10; CDS_LIB: integrated_circuits; VENDOR: Semtech; MYPN: D-RCLAMP0524PATCT
D13H D20H = Tranzorb: On Semi 5.0V standoff TVS diode; VENDOR: On Semiconductor; MYPN: D-ESD5Z5.0T1G
F10H F11H = FUSE0805: Murata 140mA fuse, 40mA hold; PART_NUMBER: M00014-001; CDS_LMAN_SYM_OUTLINE: -75,50,75,-50; OriginalSymbolOrigin: (-125,50); LOCATION: F1; XY: (-4350,3000); VER: 1; ROT: 0; PHYS_PAGE: 10; PATH: I13; DRAWING: @BROWNSTONE_LIB.BROWNSTONE(SCH_1):PAGE10; CDS_LIB: fuses
J10H J11H J12H = Header 19: Molex HDMI connector, Type A; MYPN: J-HDMI-SMT-RA-A-MALE
P10H = HDMI-TYPE-D: HDMI Type D with through-hole mounts; MPN: 0467651301; VENDOR: Molex; MYPN: J-HDMI-D-THMNT
P11H = Header 11X2: Header, 11-Pin, Dual row
P12H = USB_MINI-AB_1: Micro USB B type connector; VENDOR: FCI/BERG; MYPN: J-MICROUSB-SMT-FCI
P13H = CMP-0001-00031-1: Golden finger, PCIeX4, Dual, Opposite, Pitch 1mm, 64-Position; Mating Connector: Molex-87715-9106
Q10H Q13H = MOSFET-P: P-Channel MOSFET; VENDOR: ON Semiconductor; MYPN: Q-BSS84
Q11H Q12H Q14H Q15H = MOSFET-N: N-Channel MOSFET; VENDOR: ON Semiconductor; MYPN: Q-FDV301N
Q16H Q17H Q18H = MOSFET-N: N-Channel MOSFET; MPN: BSS138LT1G; VENDOR: ON Semiconductor; MYPN: Q-BSS138LT1G
R10H R40H = Res1: Resistor; VENDOR: ANY; MYPN: R-104-1P-1_16W-0402
R11H R12H R13H R14H R19H R21H R22H R25H = RPACK2: MPN: RP102PJ470CS; MFG: SAMSUNG; MYPN: RP-RP102PJ470CS
R15H R18H R26H R28H R30H R32H = Res1: Resistor; VENDOR: ANY; MYPN: R-390-1P-1_16W-0402
R16H R17H R20H R27H R29H R31H R34H = Res1: Resistor; MPN: RS02U102FT; VENDOR: Fenghua; MYPN: R-102-1P-1_16W-0402
R23H = Res1: Resistor; MPN: RS02U152FT; VENDOR: Fenghua; MYPN: R-152-1P-1_16W-0402
R24H = Res1: Resistor; VENDOR: Fenghua
R33H = Res1: Resistor; MPN: RS02U103FT; VENDOR: Fenghua; MYPN: R-103-1P-1_16W-0402
R35H R36H R41H R42H R43H R44H = Res1: Resistor; MPN: RS02U182FT; Value: 100k; VENDOR: Fenghua; MYPN: R-182-1P-1_16W-0402
R37H R39H = Res1: Resistor; VENDOR: ANY
R38H = Res1: Resistor; VENDOR: ANY; MYPN: R-0-1P-1_16W-0402
TP10H TP11H TP12H TP13H = CON1: Connector
U10H = 74AC04SC: Hex Inverter, 14-Pin SOIC, Commercial Grade; MPN: 74VHC04MTCX; IC_Technology: AC; VENDOR: ON Semiconductor; MYPN: U-74VHC04MTC
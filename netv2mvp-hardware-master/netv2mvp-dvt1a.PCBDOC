# Altium PCB netv2mvp-dvt1a.PCBDOC (part 4 of 6)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 90 x 100 mm, 6 copper layers (L1, L2, L3, L4, L5, L6), stack 1.542 mm thick; 329 components, 277 nets, 2092 pads, 848 vias.

## Via types
v1: diameter 0.5, hole 0.25, L1 to L6, tented both sides, 789 vias
v2: diameter 0.45, hole 0.25, L1 to L6, tented both sides, 57 vias
v3: diameter 0.5, hole 0.25, L1 to L6, tented top, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
FUSB_P: R24H.2 R30H.1 U10F.C14 | length 75.6
  L1 w0.1: U10F.C14@40.243,31.222 v1(40.939,31.222) ; R24H.2@73,70.35 R30H.1@74.175,70.35 74.687,69.838 74.687,67.187 v1(74.5,67)
  L4 w0.1: v1(40.939,31.222) 40.939,30.656 41.11,30.485 42.201,30.485 42.966,31.25 43.633,31.25 43.983,30.9 46.35,30.9 47.825,32.375 52.458,32.375 52.708,32.125 61.025,32.125 62.075,33.175 67.8,33.175 70.175,35.55 70.175,42.05 79.925,51.8 79.925,61.075 74.7,66.3 v1@74.7,67
FUSBD_N: P12H.2 R28H.2 | length 3.3
  L1 w0.1: P12H.2@75.05,74.475 75.05,73.55 74.825,73.325 74.825,72.675 74.9,72.6 74.9,72.05 R28H.2@75.4,71.55
FUSBD_P: P12H.3 R30H.2 | length 3.3
  L1 w0.1: R30H.2@74.175,71.55 74.7,72.075 74.7,72.517 74.625,72.592 74.625,73.325 74.4,73.55 P12H.3@74.4,74.475
GND: C10C.2 C10D.1 C10F.2 C10H.2 C10P.2 C11C.2 C11D.2 C11F.2 C11H.2 C11P.2 C12C.2 C12D.2 C12F.2 C12H.2 C12P.2 C13C.2 C13D.2 C13F.2 C13P.2 C14D.2 C14F.2 C14P.2 C15D.2 C15F.2 C15P.2 C16C.2 C16D.2 C16F.2 C16P.2 C17C.2 C17D.2 C17F.2 C17P.2 C18C.2 C18D.2 C18F.2 C18P.2 C19C.2 C19D.2 C19F.2 C19P.2 C20C.2 C20D.2 C20P.2 C21C.2 C21D.2 C21P.2 C22C.2 C22D.2 C22P.2 C23C.2 C23D.2 C23P.2 C24D.2 C24P.2 C25D.2 C25P.2 C26D.2 C26F.2 C26P.2 C27D.1 C27P.2 C28D.2 C28F.2 C29D.1 C29F.2 C29P.2 C30D.1 C30F.2 C30P.2 C31D.2 C31F.2 C31P.2 C32D.2 C32F.2 C32P.1 C33D.1 C33F.2 C33P.2 C34D.1 C34F.2 C34P.1 C35D.1 C35F.2 C35P.1 C36D.2 C37D.2 C37P.2 C38D.2 C38F.2 C38P.2 C39D.2 C39F.2 C40D.2 C41D.2 C41F.2 C42D.1 C42F.2 C43D.1 C43F.2 C44D.2 C44F.2 C45D.2 C45F.2 C46D.2 C46F.2 C47D.2 C47F.2 C48D.2 C48F.2 C49D.1 C49F.2 C50F.2 C51F.2 C52F.2 C53F.2 C54F.2 C55F.2 C56F.2 C57F.2 C58F.2 C59F.2 C60F.2 C61F.2 C62F.2 C63F.2 C64F.2 C65F.2 C66F.2 C67F.2 C68F.2 C69F.2 C70F.2 C71F.2 C72F.2 C73F.2 C74F.2 C75F.2 C76F.2 C77F.2 C78F.2 C79F.2 C80F.2 C81F.2 C82F.2 C83F.2 C84F.2 C85F.2 C86F.2 C87F.2 C88F.2 C89F.2 D10F.2 D10H.3 D10P.2 D11F.2 D11H.3 D12F.2 D12H.3 D13H.2 D14H.3 D15H.3 D16H.3 D17H.3 D18H.3 D19H.3 D20H.2 D21H.3 D22H.3 D23H.3 J10H.0 J10H.2 J10H.5 J10H.8 J10H.11 J10H.17 J11H.0 J11H.2 J11H.5 J11H.8 J11H.11 J11H.17 J12H.0 J12H.2 J12H.5 J12H.8 J12H.11 J12H.17 JP10P.2 JP10P.3 P10C.4 P10H.0 P10H.4 P10H.7 P10H.10 P10H.13 P10H.16 P11C.5 P11C.10 P11C.13 P11C.19 P11H.11 P11H.12 P11H.21 P11H.22 P12C.0 P12C.5 P12H.0 P12H.5 P13H.A4 P13H.A12 P13H.A15 P13H.A18 P13H.A20 P13H.A23 P13H.A24 P13H.A27 P13H.A28 P13H.A31 P13H.B4 P13H.B7 P13H.B13 P13H.B16 P13H.B18 P13H.B21 P13H.B22 P13H.B25 P13H.B26 P13H.B29 P13H.B32 Q11H.2 Q12H.2 Q14H.2 Q15H.2 R10D.1 R10F.2 R10H.1 R11D.1 R13C.2 R14D.1 R15F.1 R16P.2 R17H.2 R17P.2 R18C.2 R20H.2 R25P.2 R26P.2 R31H.2 R31P.1 R32P.1 R33H.2 R34H.2 R39H.2 R40H.1 SW10C.1 SW10C.2 TP11H.1 TP13H.1 U10C.4 U10D.A9 U10D.B1 U10D.B3 U10D.B9 U10D.D1 U10D.D8 U10D.E1 U10D.E2 U10D.E8 U10D.F9 U10D.G1 U10D.G8 U10D.G9 U10D.J2 U10D.J8 U10D.M1 U10D.M9 U10D.P1 U10D.P9 U10D.T1 U10D.T9 U10F.A2 U10F.A3 U10F.A5 U10F.A7 U10F.A9 U10F.A11 U10F.A12 U10F.A22 U10F.AA2 U10F.AA12 U10F.AA22 U10F.AB9 U10F.AB19 U10F.B3 U10F.B12 U10F.B19 U10F.C3 U10F.C6 U10F.C10 U10F.C12 U10F.C16 U10F.D3 U10F.D4 U10F.D8 U10F.D12 U10F.D13 U10F.E4 U10F.E5 U10F.E7 U10F.E9 U10F.E11 U10F.E20 U10F.F5 U10F.F11 U10F.F17 U10F.G5 U10F.G6 U10F.G7 U10F.G8 U10F.G9 U10F.G10 U10F.G12 U10F.G14 U10F.H1 U10F.H7 U10F.H9 U10F.H11 U10F.H21 U10F.J8 U10F.J10 U10F.J12 U10F.J18 U10F.K5 U10F.K7 U10F.K9 U10F.K11 U10F.K15 U10F.L2 U10F.L8 U10F.L9 U10F.L10 U10F.L22 U10F.M7 U10F.M9 U10F.M10 U10F.M11 U10F.M19 U10F.N6 U10F.N8 U10F.N9 U10F.N10 U10F.N16 U10F.P3 U10F.P7 U10F.P9 U10F.P11 U10F.P13 U10F.R8 U10F.R10 U10F.R12 U10F.R20 U10F.T7 U10F.T9 U10F.T11 U10F.T17 U10F.U4 U10F.U10 U10F.U14 U10F.V1 U10F.V11 U10F.V21 U10F.W8 U10F.W18 U10F.Y5 U10F.Y15 U10H.7 U10P.B1 U10P.B2 U10P.B3 U10P.B4 U10P.C1 U10P.C2 U10P.C3 U10P.C4 U11C.4 U11C.15 U11C.16 U11C.31 U11C.47 U11D.A9 U11D.B1 U11D.B3 U11D.B9 U11D.D1 U11D.D8 U11D.E1 U11D.E2 U11D.E8 U11D.F9 U11D.G1 U11D.G8 U11D.G9 U11D.J2 U11D.J8 U11D.M1 U11D.M9 U11D.P1 U11D.P9 U11D.T1 U11D.T9 U11F.2 U11P.B1 U11P.B2 U11P.B3 U11P.B4 U11P.C1 U11P.C2 U11P.C3 U11P.C4 U12P.B1 U12P.B2 U12P.B3 U12P.B4 U12P.C1 U12P.C2 U12P.C3 U12P.C4 U13P.B1 U13P.B2 U13P.B3 U13P.B4 U13P.C1 U13P.C2 U13P.C3 U13P.C4 U14P.B2 U15P.4 U15P.8 U15P.11 U16P.1 | length 667.7
  L1 w0.18: v1(72.819,60.656) U15P.8@73.325,60.15 ; U15P.4@75.175,58.875 v1(75.681,58.369)
  L1 w0.2: v1(32.1,74.85) 32.4,74.55 P10H.4@32.4,73.75 ; v1(33,71.675) P10H.7@33,72.525 ; v1(33.172,43.235) U10F.T11@33.172,42.536 v1(33.871,42.536) ; P10H.10@33.6,73.75 v1(33.6,75.075) ; v1(34.2,71.65) P10H.13@34.2,72.525 ; P10H.16@34.8,73.75 34.8,74.525 v1(35.2,74.925) ; v2(54.693,52.25) U11D.D8@55.23,52.25 ; U11D.E8@55.796,52.816 v2(55.796,53.353) ; U11D.G9@56.362,54.513 U11D.G8@56.927,53.947 ; U11D.B3@56.927,48.29 v2@56.948,47.731 ; v2(57.522,55.078) U11D.J8@58.059,55.078 ; v2(59.19,48.884) U11D.E2@59.19,49.421 ; v2(61.453,51.147) U11D.J2@61.453,51.684 ; v1(64.225,46.75) C35D.1@64.9,46.75 ; v1(64.878,61.325) R11D.1@65.975,61.325 ; v1(66.951,49.581) C27D.1@67.428,49.103 ; C20D.2@68.124,46.124 v1(68.725,46.725) ; v1(69.45,47.4) 70.03,47.98 C26D.2@70.03,48.022 ; v1(71.634,49.65) C28D.2@72.23,50.247 ; v1(71.9,54.53) C34D.1@72.378,54.053 ; C16C.2@86.575,46.725 86.575,47.15 SW10C.1@88.075,48.65 SW10C.2@88.075,54.15
  L1 w0.25: D11F.2@2,63.55 0.875,62.425 0.875,59.95 1.775,59.05 D12F.2@2.025,59.05 2.025,56.665 J10H.0@3.44,55.25 ; R32P.1@5.375,68.075 v1(6.475,68.075) ; v1(8.15,20) J11H.2@10.16,20 ; v1(8.15,21.5) J11H.5@10.16,21.5 ; v1(8.15,23) J11H.8@10.16,23 ; v1(8.15,24.5) J11H.11@10.16,24.5 ; v1(8.15,27.5) J11H.17@10.16,27.5 ; v1(8.15,44) J10H.2@10.16,44 ; v1(8.15,45.5) J10H.5@10.16,45.5 ; v1(8.15,47) J10H.8@10.16,47 ; v1(8.15,48.5) J10H.11@10.16,48.5 ; v1(8.15,51.5) J10H.17@10.16,51.5 ; v1(12.6,44.75) D12H.3@13.925,44.75 v1(15.25,44.75) ; v1(12.6,48.125) D11H.3@13.925,48.125 v1(15.25,48.125) ; v1(12.6,51.675) D10H.3@13.925,51.675 v1(15.25,51.675) ; v1(12.65,20.725) D16H.3@13.975,20.725 v1(15.3,20.725) ; v1(12.65,24) D15H.3@13.975,24 v1(15.3,24) ; v1(12.65,27.4) D14H.3@13.975,27.4 v1(15.3,27.4) ; v1(21.46,37.44) 21.858,37.838 U10F.AA22@21.858,38.293 ; v1(22.767,41.627) U10F.AB19@23.272,41.121 ; U10F.V21@24.686,36.879 v1(24.686,37.594) ; U10F.W18@26.101,39.707 v1(26.815,39.707) ; U10F.R20@27.515,35.464 v1(27.515,36.179) ; U10F.Y15@27.515,42.536 v1(27.515,43.251) ; v1(28.423,30.716) U10F.L22@28.929,31.222 ; v1(28.929,37.578) U10F.T17@28.929,38.293 ; U10F.AA12@28.929,45.364 v1(28.929,46.079) ; v1(29.628,34.05) U10F.M19@30.343,34.05 ; U10F.U14@30.343,41.121 v1(30.343,41.836) ; U10F.AB9@30.343,48.192 v1(30.343,48.907) ; D23H.3@31.15,69.45 v1(31.15,70.7) ; U10F.H21@31.757,29.808 v1(32.472,29.808) ; v1(31.757,36.164) U10F.N16@31.757,36.879 ; U10F.V11@31.757,43.95 v1(31.757,44.665) ; v1(32.457,39.707) U10F.P13@33.172,39.707 ; v1(32.457,41.121) U10F.R12@33.172,41.121 v1(33.871,41.121) U10F.P11@34.586,41.121 ; v1(33.172,31.921) U10F.J18@33.172,32.636 ; v1(33.172,43.235) U10F.U10@33.172,43.95 ; U10F.W8@33.172,46.778 v1(33.172,47.493) ; v1(33.871,42.536) U10F.R10@34.586,42.536 ; D22H.3@34.575,69.45 v1(34.575,70.7) ; v1(34.586,27.678) U10F.E20@34.586,28.393 ; v1(34.586,34.749) U10F.K15@34.586,35.464 ; U10F.Y5@34.586,49.607 v1(34.586,50.322) ; v1(35.285,31.222) U10F.F17@36,31.222 ; v1(36,23.436) U10F.A22@36,24.151 ; U10F.M11@36,39.707 v1(36,40.422) ; v1@36,46.079 v1(36,46.05) U10F.T7@36,45.364 U10F.R8@36,43.95 v1(36,43.251) U10F.P9@36,42.536 ; U10F.AA2@36,52.435 v1(36,53.15) ; v1(36.699,38.293) U10F.K11@37.414,38.293 ; v1(36.699,43.95) U10F.P7@37.414,43.95 ; P10H.0@36.96,74.2 R40H.1@39.075,74.2 ; v1(37.414,26.264) U10F.B19@37.414,26.979 ; v1(37.414,33.335) U10F.G14@37.414,34.05 ; U10F.J12@37.414,36.879 37.441,36.852 v1(38.127,36.852) 38.127,36.876 38.129,36.879 U10F.H11@38.828,36.879 ; U10F.L10@37.414,39.707 v1@37.414,40.406 ; U10F.M9@37.414,41.121 v1@36.707,41.121 ; U10F.N8@37.414,42.536 v1(36.699,42.536) ; U10F.U4@37.414,48.192 37.427,48.205 v1(37.427,48.877) ; v1(37.422,40.414) U10F.M10@36.707,40.414 ; v1(37.422,41.828) U10F.N9@36.707,41.828 ; U10F.L9@38.121,40.414 v1(38.121,41.129) ; v1(38.325,68.2) D21H.3@38.325,69.45 v1(38.325,70.7) ; R17P.2@38.75,21.225 38.75,21.35 v1(39.475,22.075) ; v1(38.825,43.36) U10F.N6@38.825,44.075 ; v1(38.828,29.093) U10F.C16@38.828,29.808 ; v1(38.828,34.749) U10F.G12@38.828,35.464 ; U10F.J10@38.828,38.293 v1(39.543,38.293) U10F.H9@40.243,38.293 ; U10F.K9@38.828,39.707 v1(38.828,40.422) ; U10F.L8@38.828,41.121 v1(38.828,41.836) ; U10F.V1@38.828,51.021 v1(38.828,51.736) ; v1(40.243,31.921) U10F.D13@40.243,32.636 v1@40.95,32.636 ; v1(40.243,34.749) U10F.F11@40.243,35.464 ; U10F.G10@40.243,36.879 v1@40.243,37.594 ; v1(40.243,37.578) U10F.H9@40.243,38.293 ; U10F.J8@40.243,39.707 v1(40.243,40.422) ; U10F.K7@40.243,41.121 v1(40.243,41.836) ; U10F.P3@40.243,46.778 v1(40.243,47.493) ; v1(40.95,32.628) v1@40.95,32.636 ; U10F.E11@40.95,34.757 v1(40.95,34.042) U10F.D12@40.95,33.343 v1@40.95,32.636 ; U10F.G9@40.95,37.586 v1@40.95,38.293 ; v1(40.95,38.301) v1@40.95,38.293 ; v1(40.975,17.625) C13P.2@41.65,17.625 ; C12P.2@41.65,16.125 C12P.2@41.95,16.425 ; C12P.2@41.65,16.325 C13P.2@41.65,17.625 ; v1(41.657,37.578) U10F.G8@41.657,38.293 v1@40.95,38.293 ; v1(41.657,40.422) U10F.H7@41.657,39.707 41.665,39.715 v1(42.364,39.715) U10F.G7@42.364,39 ; U10F.K5@41.657,42.536 v1(41.657,43.251) ; C12P.2@41.85,16.525 C12P.2@41.95,16.425 ; 41.85,16.725 C13P.2@41.85,17.625 ; C12P.2@42.05,16.35 v1@42.05,18.45 ; C12P.2@42.05,16.525 C12P.2@41.95,16.425 ; v1(42.356,34.05) U10F.C10@43.071,34.05 ; v1(42.364,31.214) U10F.B12@42.364,31.929 41.665,31.929 v1(41.657,31.921) U10F.C12@41.657,32.636 v1@40.95,32.636 ; v1(42.364,35.457) U10F.E9@42.364,36.172 ; v1@42.372,39.707 U10F.G6@43.071,39.707 v1@43.778,39.707 ; v1(43.071,30.507) U10F.A12@43.071,31.222 ; U10F.L2@43.071,45.364 v1(43.071,46.079) ; U10F.A11@43.778,31.929 v1(44.284,31.423) ; v1(43.778,35.457) U10F.D8@43.778,36.172 v1(43.778,36.871) U10F.E7@43.778,37.586 ; v1(43.778,39.699) v1@43.778,39.707 ; U10F.G5@43.778,40.414 v1@43.778,39.707 ; v1(44.485,40.422) U10F.F5@44.485,39.707 ; U10F.A9@45.192,33.343 v1(45.698,32.838) ; U10F.E5@45.192,39 v1@45.192,39.707 ; v1(45.192,39.715) v1@45.192,39.707 ; U10F.C6@45.899,36.879 v1(45.899,37.594) ; v1(45.899,38.992) U10F.E4@45.899,39.707 ; U10F.H1@45.899,43.95 v1(46.405,44.455) ; v1@46.599,39.707 U10F.E4@45.899,39.707 ; U10F.A7@46.607,34.757 v1(47.112,34.252) ; U10F.D4@46.607,39 v1(46.607,39.715) U10F.D3@47.314,39.715 ; U10F.D3@47.314,39.707 U10F.D3@47.314,39.715 ; v1(47.314,40.422) U10F.D3@47.314,39.715 ; U10F.A5@48.021,36.172 v1(48.736,36.172) ; J12H.2@49,68.64 v1(49,70.7) ; v1(49.325,63.375) D19H.3@49.325,64.85 v1@49.325,65.925 ; U10F.A3@49.435,37.586 v1(50.15,37.586) ; U10F.A3@49.443,37.594 v1(49.443,38.293) ; J12H.5@50.5,68.64 v1(50.5,70.7) ; v1(50.857,38.293) U10F.A2@50.142,38.293 v1(49.443,38.293) ; J12H.8@52,68.64 v1(52,70.7) ; C26P.2@52.025,31.375 52.45,31.375 v1(52.675,31.15) ; v1(52.775,63.375) D18H.3@52.775,64.85 v1(52.775,66.35) ; U14P.B2@53.275,31.85 53.65,31.475 C27P.2@54.175,31.475 v1(54.85,31.475) ; J12H.11@53.5,68.64 v1(53.5,70.7) ; R16P.2@55.85,32 56.025,31.825 v1(56.025,30.85) ; v1(56.35,63.4) D17H.3@56.35,64.875 v1(56.35,66.35) ; J12H.17@56.5,68.64 v1(56.5,70.7) ; v2@59.19,48.842 U11D.D1@59.19,48.29 59.19,48.219 v1(59.65,47.759) ; v1(59.45,34) C11P.2@59.45,34.675 ; R33H.2@60.175,64.525 v1(61.3,64.525) ; 60.35,34.875 C11P.2@59.45,34.875 ; v1(60.35,47.059) C17D.2@60.852,46.558 ; C10P.2@60.55,34.875 C10P.2@60.65,34.975 ; C10P.2@60.55,35.075 C10P.2@60.65,34.975 ; C10P.2@60.725,35.075 v1@58.625,35.075 ; C10P.2@60.75,34.675 C11P.2@59.45,34.675 ; C10P.2@60.95,34.675 C10P.2@60.65,34.975 ; v1(61.119,47.564) C23D.2@61.488,47.194 ; v1(62.25,48.695) C12D.2@62.62,48.325 ; v1(63.2,76.475) C12H.2@64.075,76.475 ; C18P.2@69.575,70.1 C18P.2@69.675,70.2 ; C18P.2@69.575,70.275 v1@69.575,68.175 ; 69.775,69.9 C19P.2@69.775,69 ; C18P.2@69.775,70.1 C18P.2@69.675,70.2 ; C18P.2@69.975,70.3 C19P.2@69.975,69 ; C18P.2@69.975,70.5 C18P.2@69.675,70.2 ; v1(70.65,69) C19P.2@69.975,69 ; C37P.2@72.022,58.428 v1(72.528,57.922) 72.697,57.922 v1(73.244,58.469) U15P.11@73.75,58.975 ; v1(72.875,64.55) R25P.2@72.875,65.4 ; U15P.11@74.425,59.7 v1(74.931,60.206) 75.222,60.497 C31P.2@75.222,60.853 ; v1(74.969,51.844) C13D.2@75.475,52.35 ; C13D.2@75.825,52.025 v1(76.331,51.519) ; C13D.2@76.3,53.325 v1(76.806,53.831) ; C13D.2@76.65,52.875 v1(77.156,52.369) ; C29P.2@76.675,58.45 v1(76.675,59.165) ; C29P.2@77.2,57.95 v1(77.706,58.456) ; C30P.2@78.625,57.8 v1(79.131,58.306) ; C30P.2@78.725,57.275 v1(79.231,56.769) ; C20P.2@85.075,70.525 C20P.2@85.175,70.625 ; C20P.2@85.075,70.7 v1@85.075,68.6 ; 85.275,70.325 C21P.2@85.275,69.425 ; C20P.2@85.275,70.525 C20P.2@85.175,70.625 ; C20P.2@85.475,70.725 C21P.2@85.475,69.425 ; C20P.2@85.475,70.925 C20P.2@85.175,70.625 ; v1(86.15,69.425) C21P.2@85.475,69.425 ; v1(88.375,64.975) R26P.2@88.375,65.825 ; v1(36,40.422) U10F.N10@36,41.121 ; v1(36,40.422) 36.008,40.414 U10F.M10@36.707,40.414 ; U10F.N10@36,41.121 v1(36,41.836) U10F.P9@36,42.536 ; U10F.N10@36,41.121 v1(36.699,41.121) v1@36.707,41.121 ; U10F.P9@36,42.536 v1(36.699,42.536) ; v1(36.699,42.536) 36.707,42.528 U10F.N9@36.707,41.828 ; U10F.M10@36.707,40.414 v1@36.707,41.121 ; v1@36.707,41.121 U10F.N9@36.707,41.828 ; U10F.H9@40.243,38.293 v1@40.95,38.293 ; C13P.2@41.65,17.625 C13P.2@41.85,17.625 ; C13P.2@41.65,17.625 v1@41.65,18.475 ; v1@41.65,18.475 v1@42.05,18.475 ; v1@41.65,18.475 U11P.B2@41.65,19.275 U11P.B4@41.65,20.075 v1@41.65,20.5 ; v1@41.65,20.5 v1@41.85,20.5 ; v1@41.65,20.5 41.65,21.525 41.675,21.55 C17P.2@41.85,21.375 ; C13P.2@41.85,17.625 41.825,17.65 41.825,18.45 v1@42.05,18.45 ; v1@41.85,20.5 C17P.2@41.85,21.375 ; v1@41.85,20.5 42.025,20.5 42.05,20.475 ; C17P.2@41.85,21.375 42.05,21.175 42.05,20.475 ; v1@42.05,18.45 v1@42.05,18.475 ; v1@42.05,18.475 42.05,20.475 ; v1@43.778,39.707 U10F.F5@44.485,39.707 ; U10F.F5@44.485,39.707 v1@45.192,39.707 ; v1@45.192,39.707 U10F.E4@45.899,39.707 ; U10F.D3@47.314,39.715 v1(48.021,39.715) U10F.C3@48.021,39 U10F.B3@48.728,38.293 v1(49.443,38.293) ; C15P.2@55.7,34.875 v1(56.45,34.875) v1@56.575,34.875 ; C15P.2@55.7,34.875 55.9,35.075 56.6,35.075 ; C15P.2@55.7,34.875 C15P.2@55.525,34.7 55.55,34.675 v1@56.575,34.675 ; v1@56.575,34.675 v1@56.575,34.875 ; v1@56.575,34.675 U10P.B4@57,34.675 U10P.B2@57.8,34.675 v1@58.6,34.675 ; v1@56.575,34.875 56.575,35.05 56.6,35.075 ; 56.6,35.075 U10P.C4@57,35.075 U10P.C3@57.4,35.075 U10P.C2@57.8,35.075 U10P.C1@58.2,35.075 v1@58.6,35.075 ; v1@58.6,34.675 C11P.2@59.45,34.675 ; v1@58.6,34.675 v1@58.6,35.075 ; v1@58.6,35.075 v1@58.625,35.075 ; v1@58.625,35.075 58.625,34.85 59.425,34.85 C11P.2@59.45,34.875 ; C11P.2@59.45,34.675 C11P.2@59.45,34.875 ; 69.575,66.15 69.6,66.125 v1@69.775,66.125 ; 69.575,66.15 69.575,65.45 C23P.2@69.775,65.25 ; 69.575,66.15 U12P.C4@69.575,66.55 U12P.C3@69.575,66.95 U12P.C2@69.575,67.35 v1@69.575,68.15 ; v1@69.575,68.15 v1@69.575,68.175 ; v1@69.575,68.15 v1@69.975,68.15 ; v1@69.575,68.175 69.8,68.175 69.8,68.975 C19P.2@69.775,69 ; C23P.2@69.775,65.25 69.95,65.075 69.975,65.1 v1@69.975,66.125 ; C23P.2@69.775,65.25 v1@69.775,66.125 ; v1@69.775,66.125 v1@69.975,66.125 ; C19P.2@69.775,69 C19P.2@69.975,69 ; v1@69.975,66.125 U12P.B4@69.975,66.55 U12P.B2@69.975,67.35 v1@69.975,68.15 ; v1@69.975,68.15 C19P.2@69.975,69 ; 85.075,66.575 v1@85.075,68.575 ; 85.075,66.575 85.1,66.55 v1@85.275,66.55 ; 85.075,66.575 85.075,65.875 C24P.2@85.275,65.675 ; v1@85.075,68.575 v1@85.075,68.6 ; v1@85.075,68.575 v1@85.475,68.575 ; v1@85.075,68.6 85.3,68.6 85.3,69.4 C21P.2@85.275,69.425 ; C24P.2@85.275,65.675 85.45,65.5 85.475,65.525 v1@85.475,66.55 ; C24P.2@85.275,65.675 v1@85.275,66.55 ; v1@85.275,66.55 v1@85.475,66.55 ; C21P.2@85.275,69.425 C21P.2@85.475,69.425 ; v1@85.475,66.55 U13P.B4@85.475,66.975 U13P.B2@85.475,67.775 v1@85.475,68.575 ; v1@85.475,68.575 C21P.2@85.475,69.425
  L1 w0.254: C37D.2@51.483,53.452 51.483,52.603 v1(52.475,51.611) ; C37D.2@51.765,53.452 v1(53.05,52.167) U11D.B9@53.533,51.684 ; v1@52.549,51.684 v1(52.475,51.611) ; U11D.A9@52.968,51.119 v1(52.475,51.611) ; C25D.2@54.064,55.609 55.725,53.947 U11D.F9@55.796,53.947 v2(55.796,53.353) ; C18D.2@54.7,56.245 54.7,56.174 v1(55.869,55.005) U11D.G9@56.362,54.513 ; v1(55.45,58.625) 55.75,58.625 55.845,58.72 R14D.1@56.114,58.72 ; v1(56.127,59.427) C31D.2@56.821,59.427 ; U11D.B1@58.059,47.159 v1(58.551,46.666) v1@58.551,46.596 ; C16D.2@58.589,60.134 59.758,58.965 v1(59.829,58.965) U11D.P9@60.321,58.472 ; v1(58.698,57.833) U11D.M9@59.19,57.341 ; v1(59.247,45.9) C14D.2@59.72,45.426 ; C15D.2@59.402,62.644 59.791,62.255 C45D.2@59.791,61.336 60.417,61.336 v1(61.453,60.3) U11D.T9@61.453,59.604 ; U11D.E1@59.756,48.856 v1(60.248,48.363) ; U11D.G1@60.887,49.987 v1(61.379,49.495) v1@61.45,49.495 ; U11D.M1@63.716,52.816 64.2,52.331 v1(64.2,52.25) ; U11D.P1@64.847,53.947 65.344,53.45 65.375,53.45 65.375,53.42 65.339,53.384 C19D.2@66.509,52.215 ; C30D.1@65.249,50.749 65.499,50.749 66.323,49.925 66.606,49.925 v1(66.951,49.581) ; U11D.T1@65.978,55.078 66.05,55.15 v1(66.825,55.15) 66.825,54.302 C22D.2@67.711,53.417 ; v1(69.281,52.2) C29D.1@69.903,51.578
  L1 w0.3: J10H.0@9.4,55.25 11.3,55.25 11.75,55.7 R10H.1@12.3,55.7 ; R31P.1@14.5,79.125 13.85,78.475 13.85,75.77 U16P.1@14.77,74.85 ; Q15H.2@15.925,56.075 v1(15.925,57.025) ; Q14H.2@19.925,56.075 v1(19.925,56.95) ; v1(21.625,69.3) U10C.4@22.595,69.3 ; C10C.2@27.9,63.575 v1(27.9,64.3) ; U10F.U10@33.172,43.95 U10F.T9@34.586,43.95 ; v1(38.828,41.836) U10F.M7@38.828,42.536 v1@38.828,43.357 ; v1(63.55,34.35) C17C.2@63.55,33.3 63.95,33.7 C19C.2@64.8,33.7 65.075,33.975 U11C.47@66.5,33.975 ; U11C.31@68.8,42.775 v1(68.8,45.225) ; v1(70.85,71.5) 70.85,71.7 R39H.2@71.475,72.325 ; P12H.5@73.1,74.475 73.1,73.45 72.825,73.175 72.2,73.175 71.5,73.875 P12H.0@71.5,74.27 71.5,76.65 P12H.0@71.675,76.825 P12H.0@77.125,76.825 77.3,76.65 P12H.0@77.3,74.27 ; v1(77.575,41.925) 78.75,41.925 79.275,41.4 ; U11C.4@77.6,34.975 79.125,34.975 C20C.2@79.35,34.75 79.6,34.75 v1(80.025,34.325) ; U11C.15@77.6,40.475 78.7,40.475 C22C.2@80.575,42.35 ; U11C.16@77.6,40.975 78.85,40.975 79.275,41.4 ; v1(78.325,68.475) C11H.2@78.325,69.575 ; C12C.2@80.9,37.55 v1(81.875,37.55) ; v1(81.575,42.35) C22C.2@80.6,42.35 C22C.2@80.575,42.35 ; R18C.2@83.275,43.525 83.65,43.525 84.575,42.6 P12C.5@85.575,42.6 ; P12C.0@85.37,38.4 87.75,38.4 P12C.0@87.925,38.575 P12C.0@87.925,44.025 87.895,43.995 P12C.0@85.575,43.995 ; 79.275,41.4 80.225,42.35 C22C.2@80.575,42.35
  L1 w0.4: D10F.2@2,35.05 2,32.69 J11H.0@3.44,31.25 ; R17H.2@5.85,34.2 6.175,33.875 Q11H.2@7.475,33.875 ; Q11H.2@7.6,33.85 7.6,32.05 8.4,31.25 J11H.0@9.4,31.25 ; J10H.0@9.9,40.75 R20H.2@11.65,39 11.25,38.6 Q12H.2@11.25,37.375 ; P13H.B4@48.65,3.5 v1(48.65,6.75) v1(48.65,7.7) ; P13H.B7@51.65,3.5 v1(51.65,6.75) ; v1(59.175,6.75) 59.65,6.275 P13H.B13@59.65,3.5 ; v1(62.2,6.425) 62.675,5.95 P13H.B16@62.675,3.175 ; P13H.B18@64.65,3.5 v1(64.65,6.75) ; v1(67.175,6.75) 67.65,6.275 P13H.B21@67.65,3.5 ; P13H.B22@68.65,3.5 68.65,6.225 v1(69.175,6.75) ; v1(71.025,46.5) R13C.2@71.85,46.5 ; v1(71.175,6.75) 71.65,6.275 P13H.B25@71.65,3.5 ; P13H.B26@72.65,3.5 72.65,6.225 v1(73.175,6.75) ; C18C.2@73.25,45.8 v1(73.25,46.6) ; v1(75.175,6.75) 75.65,6.275 P13H.B29@75.65,3.5 ; P13H.B32@78.65,3.5 v1(78.65,6.75) ; P12C.5@85.575,42.6 P12C.0@85.575,43.995
  L1 w0.5: v1(40.425,23.25) 41.675,23.25 41.675,24 v1(41.2,24.475) 41.95,25.225 C35F.2@41.95,25.4 42.575,25.4 v1(43.05,25.875) ; v1(40.75,16.125) 41.65,16.125 C12P.2@41.65,16 ; v1(40.775,15.125) C12P.2@41.65,16 ; v1(40.8,21.75) 41.475,21.75 41.675,21.55 C16P.2@41.675,23.05 ; v1(41.65,14.925) C12P.2@41.65,16 ; v1(52.7,34.85) 52.85,34.7 C14P.2@53.825,34.7 v1(53.825,33.775) ; C14P.2@54.025,34.7 C15P.2@55.525,34.7 55.325,34.5 v1(55.325,33.825) ; v1(60.95,33.775) C10P.2@60.95,34.675 C10P.2@61.075,34.675 ; v1(61.95,33.8) C10P.2@61.075,34.675 ; v1(62.15,34.675) C10P.2@61.075,34.675 ; C22P.2@69.95,63.575 69.95,65.075 70.15,64.875 v1(70.825,64.875) ; v1(69.975,71.7) C18P.2@69.975,70.625 ; v1(70.425,62.15) 69.95,62.625 C22P.2@69.95,63.375 v1(71.2,63.375) ; v1(70.85,71.5) C18P.2@69.975,70.625 ; v1(70.875,70.5) 69.975,70.5 C18P.2@69.975,70.625 ; C25P.2@85.45,64 85.45,65.5 85.65,65.3 v1(86.325,65.3) ; v1(85.475,72.125) C20P.2@85.475,71.05 ; v1(85.925,62.575) 85.45,63.05 85.45,63.8 v1(86.7,63.8) ; v1(86.35,71.925) C20P.2@85.475,71.05 ; v1(86.375,70.925) 85.475,70.925 C20P.2@85.475,71.05
  L1 w1: JP10P.2@3.375,75.475 JP10P.3@9.475,75.475 9.475,78.85 15.075,84.45 15.375,84.75 C38P.2@17.5,84.75 ; v1(13.775,69.4) C32P.1@14.875,69.4 ; C33P.2@14.825,71.625 14.825,69.45 C32P.1@14.875,69.4 ; v1(14.875,67.35) C32P.1@14.875,69.4 ; v1(16.025,69.4) C32P.1@14.875,69.4
  L6 w0.18: 60.625,50.29 v2@61.459,51.125
  L6 w0.2: v1(30.22,25.87) 30.22,25.895 C56F.2@30.22,26.69 ; C57F.2@30.339,34.022 C57F.2@30.343,34.018 ; R15F.1@31.601,46.224 31.55,46.174 31.55,45.3 31.757,45.093 v1(31.757,44.665) ; v1(35.285,31.222) 35.343,31.279 U11F.2@36.454,31.279 ; U11F.2@36.375,31.483 U11F.2@36.49,31.369 ; v2(54.128,50.553) U10D.B3@54.665,50.553 ; U10D.E1@55.23,53.381 v2@55.767,53.381 ; U10D.E2@55.796,52.816 v2(55.796,53.353) ; v1(57.275,45.5) 57.275,46.375 U10D.A9@57.493,46.593 ; v2(57.522,55.078) U10D.J2@58.059,55.078 ; U10D.D8@58.624,48.856 v2@59.206,48.856 ; v1(58.698,57.833) U10D.M1@59.19,57.341 U10D.M1@59.19,57.449 ; v2(59.19,48.884) U10D.E8@59.19,49.421 U10D.F9@60.321,49.421 ; 60.625,50.29 60.625,50.25 ; v2(61.453,51.147) U10D.J8@61.453,51.684 ; v2@61.459,51.125 v2@61.475,51.125 ; v1(66.951,49.581) C42D.1@67.428,49.103 ; U10D.F9@60.321,49.421 U10D.G8@60.321,50.553 60.625,50.25 ; U10D.F9@60.321,49.421 U10D.G9@60.887,49.987 60.625,50.25
  L6 w0.25: v1@22.739,41.614 23.65,42.525 C83F.2@23.9,42.525 ; v1(24.686,37.594) 24.722,37.63 C81F.2@24.722,38.22 ; C84F.2@26.524,36.049 26.654,36.179 v1(27.515,36.179) ; C51F.2@28.2,37.578 v1(28.929,37.578) ; C82F.2@29.6,33.1 29.6,34.022 C57F.2@30.339,34.022 ; C57F.2@30.343,34.018 C57F.2@30.45,34.125 ; v1(30.343,41.836) 30.354,41.825 C28F.2@31.125,41.825 ; C71F.2@31.75,37.225 31.75,36.701 31.757,36.694 v1(31.757,36.164) ; v1(32.457,39.707) 32.464,39.7 C26F.2@33.075,39.7 ; C52F.2@32.85,32.425 32.85,32.243 v1(33.172,31.921) ; v1(33.172,43.235) 33.172,43.897 C46F.2@33.25,43.975 ; v1(33.172,47.493) 33.238,47.493 C76F.2@33.547,47.803 ; C78F.2@33.751,50.726 34.155,50.322 v1(34.586,50.322) 34.586,50.311 C13F.2@33.875,49.6 ; v1(33.871,41.121) 34.3,40.692 C39F.2@34.3,40.65 ; C68F.2@33.9,27.675 34.582,27.675 v1(34.586,27.678) 34.972,27.678 C54F.2@35.25,27.4 ; C55F.2@35.2,34.425 34.91,34.425 v1(34.586,34.749) 34.811,34.975 35.8,34.975 C89F.2@36.05,34.725 ; v1(35.285,31.222) 35.674,30.833 C86F.2@35.674,30.374 ; C61F.2@35.325,46.625 35.425,46.625 v1(36,46.05) C47F.2@36,45.275 ; v1(36,41.836) v1(36.699,42.536) ; v1(36,53.15) 36.525,52.625 C75F.2@36.7,52.625 ; C34F.2@36.375,38.825 36.375,38.617 v1(36.699,38.293) 37.362,38.293 C32F.2@37.453,38.203 ; v1(37.414,26.264) 37.628,26.051 C72F.2@38.251,26.051 ; v1(37.422,40.414) 37.422,40.378 C45F.2@38.075,39.725 ; v1(37.427,48.877) 37.429,48.875 C79F.2@38.125,48.875 ; v1@37.429,33.35 C80F.2@38.175,33.35 ; C29F.2@37.524,36.301 37.551,36.301 38.102,36.852 v1(38.127,36.852) 38.572,36.852 C33F.2@38.697,36.978 ; C14F.2@37.947,51.772 38.792,51.772 v1(38.828,51.736) 38.839,51.725 C63F.2@39.525,51.725 ; C69F.2@38.5,28.475 38.5,28.764 v1(38.828,29.093) C85F.2@39.53,29.795 ; C11F.2@38.825,39.025 38.828,39.028 v1(38.828,40.422) ; v1(38.828,34.749) 39.475,35.396 C31F.2@39.475,35.45 ; v1(38.828,41.836) 38.828,42.083 C43F.2@39.047,42.303 ; C62F.2@38.953,44.028 38.825,43.9 v1(38.825,43.36) 38.842,43.378 C19F.2@39.678,43.378 ; v1(39.543,38.293) 40.143,38.293 40.25,38.4 40.25,37.585 v1(40.243,37.578) C48F.2@41.025,37.578 ; v1(40.243,40.422) 40.472,40.652 C41F.2@40.472,40.878 ; v1(40.243,47.493) 40.25,47.486 C77F.2@40.25,46.675 ; v1(40.95,32.628) 41.303,32.628 C30F.2@41.475,32.8 ; v1(40.95,38.301) 41.025,38.226 C48F.2@41.025,37.578 ; C48F.2@41.025,37.425 C48F.2@41.025,37.578 ; C59F.2@41.303,40.753 41.326,40.753 v1(41.657,40.422) ; v1(41.657,31.921) 42.153,32.417 C15F.2@42.153,32.428 42.364,32.216 v1(42.364,31.214) C67F.2@41.922,30.772 ; v1(41.657,37.578) C48F.2@41.025,37.578 ; C12F.2@41.997,33.728 42.32,34.05 v1(42.356,34.05) v1@42.37,34.05 ; C60F.2@42.922,47.028 43.071,46.879 v1(43.071,46.079) 43.171,46.079 C64F.2@43.8,45.45 ; C10F.2@43.775,38.9 43.775,39.696 v1(43.778,39.699) ; C17F.2@44.999,33.301 45.235,33.301 v1(45.698,32.838) ; v1(45.192,39.715) 45.428,39.48 C18F.2@45.428,39.253 45.639,39.253 v1(45.899,38.992) ; C44F.2@45.625,38.125 45.899,37.851 v1(45.899,37.594) ; v1(46.405,44.455) 46.647,44.213 C73F.2@46.647,42.997 ; C87F.2@46.747,34.628 46.747,34.616 v1(47.112,34.252) ; v1(48.021,39.715) 48.311,39.425 C16F.2@48.45,39.425 ; C88F.2@48.072,36.153 48.092,36.172 v1(48.736,36.172) ; v1(49.443,38.293) 49.625,38.475 C74F.2@49.625,38.975 ; C65F.2@50.7,39.275 50.7,38.45 v1(50.857,38.293)
  L6 w0.254: C48D.2@51.801,53.346 52.979,52.167 v1(53.05,52.167) U10D.B1@53.533,51.684 ; v1(52.475,51.611) v1@52.549,51.684 ; v1(53.15,55.475) 53.511,55.114 C46D.2@53.569,55.114 C47D.2@52.932,54.477 53.003,54.477 U10D.D1@54.665,52.816 v2@54.665,52.279 ; C11D.2@54.7,56.174 v1(55.869,55.005) U10D.G1@56.362,54.513 ; v1(56.127,59.427) 56.655,58.899 C10D.1@56.924,58.899 ; U10D.B9@58.059,47.159 v1(58.551,46.666) 58.551,46.596 v1(59.247,45.9) 59.826,45.32 C44D.2@59.826,45.108 ; C24D.2@58.589,60.134 58.66,60.134 v1(59.829,58.965) U10D.P1@60.321,58.472 ; C21D.2@59.402,62.644 59.791,62.255 C36D.2@59.791,61.336 60.417,61.336 v1(61.453,60.3) U10D.T1@61.453,59.604 ; v1(60.248,48.363) 60.319,48.363 C40D.2@61.488,47.194 ; U10D.G9@60.887,49.987 v1(61.379,49.495) 61.45,49.495 C39D.2@62.62,48.325 ; U10D.M9@63.716,52.816 64.2,52.331 v1(64.2,52.25) ; v1(64.225,46.75) 64.831,46.75 C33D.1@64.953,46.628 ; v1(64.8,49.15) 64.8,49.445 R10D.1@65.094,49.74 ; U10D.P9@64.847,53.947 65.344,53.45 65.375,53.45 65.375,53.419 66.509,52.285 C41D.2@66.509,52.215 ; C32D.2@65.802,50.447 66.348,49.9 66.631,49.9 v1(66.951,49.581) ; U10D.T9@65.978,55.078 66.05,55.15 v1(66.825,55.15) 66.825,54.302 C38D.2@67.711,53.417 ; v1(69.281,52.2) C43D.1@69.903,51.578
  L6 w0.3: v1(15.25,44.75) 16.3,45.8 17.3,45.8 D13H.2@18.3,46.8 ; v1@15.95,57 v1(15.925,57.025) 16.6,57.7 R34H.2@18.2,57.7 ; v1(19.925,56.95) 19.925,56.175 R31H.2@20.263,55.837 ; v1(20.925,64.525) 20.925,63.925 21.2,63.65 C10H.2@21.4,63.65 ; v1(21.46,37.44) 21.46,35.74 R10F.2@21.976,35.224 ; U10H.7@26.6,68.475 v1(27.55,68.475) ; D20H.2@30.3,69.4 30.3,69.85 v1(31.15,70.7) ; C58F.2@30.45,43.975 31.14,44.665 v1(31.757,44.665) ; C53F.2@30.975,35.625 31.219,35.625 v1(31.757,36.164) ; C66F.2@32.472,43.222 33.159,43.222 v1(33.172,43.235) ; v1(33.55,54.775) 34.15,55.375 C49D.1@34.15,55.475 ; v1(35.1,54.525) C49D.1@34.15,55.475 ; v1(35.1,56.225) 34.425,55.55 C49D.1@34.15,55.55 C49D.1@34.15,55.475 ; v1(40.243,34.749) 40.243,34.218 C70F.2@40.1,34.075 v1@40.917,34.075 ; C13C.2@77.575,34.95 79.4,34.95 v1(80.025,34.325) ; C11C.2@77.575,40.45 v1(77.575,41.925)
  L6 w0.4: P13H.A4@48.65,3.5 v1(48.65,6.75) v1(48.65,7.7) ; P13H.A12@58.8,3.5 58.8,6.375 v1(59.175,6.75) ; P13H.A15@61.65,3.5 61.65,5.875 v1(62.2,6.425) ; P13H.A18@64.65,3.5 v1(64.65,6.75) ; P13H.A20@66.65,3.5 66.65,6.225 v1(67.175,6.75) ; v1(69.175,6.75) 69.65,6.275 P13H.A23@69.65,3.5 ; P13H.A24@70.65,3.5 70.65,6.225 v1(71.175,6.75) ; v1(73.175,6.75) 73.65,6.275 P13H.A27@73.65,3.5 ; P13H.A28@74.65,3.5 74.65,6.225 v1(75.175,6.75) ; v1(77.025,6.75) 77.65,6.125 P13H.A31@77.65,3.5
  L6 w0.5: v1(28.625,21.425) C50F.2@28.625,24.075 C50F.2@28.625,24.3 ; v1(28.975,26.15) 28.625,25.8 C50F.2@28.625,24.3 ; C56F.2@30.22,26.575 30.22,25.895 v1(29.55,25.225) C50F.2@28.625,24.3 ; v1(56.45,34.875) 56.425,34.9 C49F.2@56.425,38.475 ; v1(58.2,39.6) 57.425,39.6 57.4,39.625 56.425,38.65 C49F.2@56.425,38.475 ; v1(58.475,37.9) 57.9,38.475 C49F.2@56.425,38.475
  other v1: 41.825,16.975 41.85,18.35 41.85,20.625 41.675,22.4 54.675,34.7 60.1,34.85 58.725,34.875 86.95,47.475 66.125,52.725 54.175,53.325 65.4,53.45 59.825,61.925 69.95,64.225 85.45,64.65 69.775,66 49.35,66.025 85.275,66.425 69.775,68.275 85.275,68.7 69.8,69.65 85.3,70.075 13.725,72.275 14.65,72.825 8.225,73.2 9.625,73.2 10.875,73.225 12.05,73.25 14.675,73.85 85.4,74.1 89.1,74.1 11.525,74.175 13.625,74.2 85.375,77.975 19.375,90.7 23.45,90.7 19.375,95.925
  other v2: 56.95,47.731
  other v3: 73.85,59.05 74.375,59.6
HAX_0: P11H.8 U10F.B15 | length 19.5
  L1 w0.1: P11H.8@31.48,14.91 32.95,16.38 32.95,17.925 33.525,18.5 33.901,18.5 39.875,24.474 39.875,26.006 41.175,27.306 41.175,28.2 40.243,29.132 U10F.B15@40.243,29.808
HAX_1: P11H.10 U10F.B16 | length 20.4
  L1 w0.1: P11H.10@28.94,14.91 30.425,16.395 30.425,17.925 31.525,19.025 33.861,19.025 39.475,24.639 39.475,26.172 39.65,26.347 39.65,27.006 39.136,27.521 39.136,27.989 39.536,28.389 U10F.B16@39.536,29.101
HAX_2: P11H.3 U10F.B13 | length 16.8
  L1 w0.1: P11H.3@36.56,17.45 36.56,20.31 40.475,24.225 40.475,25.758 42.8,28.083 42.8,29.4 41.657,30.543 U10F.B13@41.657,31.222
HAX_3: P11H.5 U10F.A15 | length 15.2
  L1 w0.1: P11H.5@34.02,17.45 34.75,18.18 34.75,19.066 40.075,24.391 40.075,25.924 41.725,27.574 41.725,28.325 U10F.A15@40.95,29.101
HAX_4: P11H.7 U10F.A16 | length 15.7
  L1 w0.1: P11H.7@31.48,17.45 32.755,18.725 33.844,18.725 39.675,24.556 39.675,26.089 40.85,27.264 40.85,27.786 U10F.A16@40.243,28.393
HAX_5: P11H.4 U10F.A13 | length 18.7
  L1 w0.1: P11H.4@36.56,14.91 36.56,15.36 37.6,16.4 37.6,18.575 37.429,18.746 37.429,20.896 40.675,24.142 40.675,25.675 43,28 43,29.879 U10F.A13@42.364,30.515
HAX_6: P11H.6 U10F.A14 | length 18.8
  L1 w0.1: P11H.6@34.02,14.91 35.55,16.44 35.55,19.583 40.275,24.308 40.275,25.841 42.6,28.166 42.6,28.864 U10F.A14@41.657,29.808
HAX_7: P11H.9 U10F.B17 | length 17.3
  L1 w0.1: P11H.9@28.94,17.45 30.765,19.275 33.828,19.275 39.275,24.722 39.275,26.255 39.45,26.43 39.45,26.923 38.828,27.545 U10F.B17@38.828,28.393
HAX_8: P11H.16 U10F.B18 | length 25.3
  L1 w0.1: P11H.16@21.32,14.91 22.7,16.29 22.7,17.775 23.35,18.425 25.325,18.425 25.775,18.875 27.325,18.875 28.525,20.075 33.779,20.075 38.675,24.971 38.675,26.284 38.121,26.838 U10F.B18@38.121,27.686
HAX_9: P11H.13 U10F.C17 | length 22.8
  L1 w0.1: P11H.13@23.86,17.45 24.975,17.45 26.05,18.525 27.425,18.525 28.7,19.8 33.787,19.8 38.875,24.888 38.875,26.367 38.428,26.813 38.428,27.328 38.6,27.5 38.6,28 38.121,28.479 U10F.C17@38.121,29.101
HAX_10: P11H.19 U10F.C18 | length 26.9
  L1 w0.1: v1(36.714,28.393) U10F.C18@37.414,28.393
  L4 w0.1: P11H.19@16.24,17.45 16.24,18.865 17.725,20.35 29.375,20.35 36.714,27.689 v1(36.714,28.393)
HAX_11: P11H.17 U10F.C19 | length 23.7
  L1 w0.1: v1(36.707,26.987) U10F.C19@36.707,27.686
  L4 w0.1: P11H.17@18.78,17.45 18.78,18.68 19.85,19.75 30.225,19.75 35.375,24.9 35.375,25.654 v1(36.707,26.987)
HAX_12: P11H.20 U10F.B20 | length 26.7
  L1 w0.1: v1(36.707,25.572) U10F.B20@36.707,26.272
  L4 w0.1: P11H.20@16.24,14.91 17.505,16.175 19.25,16.175 20.025,16.95 20.025,18.125 20.9,19 30.85,19 36.707,24.857 v1(36.707,25.572)
HAX_13: P11H.18 U10F.A20 | length 24.8
  L1 w0.1: P11H.18@18.78,14.91 20.075,16.205 20.075,17.975 20.8,18.7 22,18.7 22.25,18.95 25.075,18.95 25.625,19.5 27.075,19.5 28.2,20.625 33.764,20.625 37.414,24.275 U10F.A20@37.414,25.565
HAX_14: P11H.14 U10F.A18 | length 22.3
  L1 w0.1: P11H.14@23.86,14.91 24.925,15.975 27,15.975 27.8,16.775 27.8,17.95 29.375,19.525 33.795,19.525 39.075,24.805 39.075,26.45 38.828,26.696 U10F.A18@38.828,26.979
HAX_15: P11H.15 U10F.A19 | length 21.7
  L1 w0.1: P11H.15@21.32,17.45 22.57,18.7 25.225,18.7 25.7,19.175 27.175,19.175 28.35,20.35 33.772,20.35 38.475,25.053 38.475,25.918 U10F.A19@38.121,26.272
HAX_CLK_N: TP12H.1 U10F.E6 | length 13.3
  L1 w0.1: U10F.E6@44.485,38.293 v1(44.485,38.993)
  L6 w0.1: v1(44.485,38.993) 44.485,39.558 43.882,40.161 43.882,41.783 44.683,42.584 44.683,43 45.95,44.267 45.95,44.6 46.25,44.9 49.6,44.9 49.7,44.8 49.7,44.275 TP12H.1@48.7,43.275
HAX_CLK_P: TP10H.1 U10F.F6 | length 13.9
  L1 w0.1: v1(43.078,39) U10F.F6@43.778,39
  L6 w0.1: v1(43.078,39) 43.078,39.565 43.682,40.169 43.682,41.866 44.483,42.667 44.483,43.083 45.75,44.35 45.75,44.683 46.167,45.1 49.683,45.1 49.9,44.883 49.9,44.3 TP10H.1@50.925,43.275
HDMI_HPD: D10H.5 D10H.6 D14H.5 D14H.6 J10H.19 J11H.19 Q15H.3 R10H.2 R32H.1 U10H.3 | length 70.2
  L1 w0.1: J11H.19@10.16,28.5 12.5,28.5 12.6,28.4 D14H.5@14.413,28.4 15,28.4 15.3,28.7 15.3,29.05 14.95,29.4 v1(12.975,29.4) ; J10H.19@10.16,52.5 12.225,52.5 12.4,52.675 D10H.6@13.487,52.675 D10H.5@14.362,52.675 15.175,52.675 ; R10H.2@12.3,54.5 13.4,54.5 Q15H.3@14.025,55.125 14.025,54.3 15.175,53.15 15.175,52.675 ; v1(16.3,51.9) 15.525,52.675 15.175,52.675
  L3 w0.1: v1(12.975,29.4) 12.975,34.225 12.2,35 12.2,39.375 11.5,40.075 11.5,49 15.15,52.65 ; v1(16.3,51.9) 15.9,51.9 15.15,52.65 ; v1(24,65.75) 20.9,65.75 18.925,63.775 18.925,58.1 14.8,53.975 14.8,53 15.15,52.65
  L6 w0.1: v1(18.925,58.9) 19.975,57.85 R32H.1@20.675,57.85 ; v1(24,65.75) U10H.3@24,68.475
HDMI_HPD_LL_N: U10F.U17 U10H.4 | length 32
  L1 w0.1: U10F.U17@28.222,39 v1(28.222,39.7)
  L4 w0.1: v1(24.65,66.95) 25.1,66.5 26.35,66.5 27.325,65.525 27.325,44.8 26.9,44.375 26.9,43.1 27.7,42.3 27.7,41.075 28.225,40.55 v1@28.225,39.7
  L6 w0.1: v1(24.65,66.95) U10H.4@24.65,68.475
I2C0_SCL: R21C.1 U10F.F13 U11C.37 | length 34.2
  L1 w0.1: v1(38.129,34.05) U10F.F13@38.825,34.05 ; R21C.1@63.45,39.6 64.075,38.975 v1(65.15,38.975) U11C.37@66.5,38.975
  L4 w0.1: v1(38.129,34.05) 38.8,34.05 39.975,35.225 40.475,35.225 40.725,34.975 41.15,34.975 41.4,35.225 41.825,35.225 42.15,34.9 43.925,34.9 44.225,35.2 44.65,35.2 44.85,35 45.45,35 45.7,35.25 46.9,35.25 47.45,34.7 50.75,34.7 51.9,35.85 53.225,35.85 54.8,37.425 60.4,37.425 61.95,38.975 v1(65.15,38.975)
I2C0_SDA: R22C.1 U10F.F14 U11C.38 | length 37
  L1 w0.1: v1(36.725,32.625) 37.175,32.175 37.625,32.175 38.121,32.671 U10F.F14@38.121,33.343 ; R22C.1@63.55,38.475 U11C.38@66.5,38.475
  L4 w0.1: v1(36.725,32.625) 36.725,33.425 37.15,33.85 37.65,33.85 37.875,33.625 38.45,33.625 38.625,33.8 40.025,33.8 40.725,34.5 41.15,34.5 41.4,34.25 41.775,34.25 42.075,34.55 43.175,34.55 43.5,34.225 45.95,34.225 46.35,33.825 50.35,33.825 52.1,35.575 53.375,35.575 54.825,37.025 60.9,37.025 62.35,38.475 v1(64.4,38.475)
LPUART0_DEBUG_RX: P10C.2 R25C.2 U11C.46 | length 24.1
  L1 w0.1: U11C.46@66.5,34.475 67.95,34.475 68.95,33.475 75.925,33.475 76.725,32.675 82.7,32.675 83,32.375 R25C.2@83,31.825 83.975,31.825 86.365,29.435 P10C.2@88.2,29.435
LPUART0_DEBUG_TX: P10C.3 R26C.2 U11C.49 | length 24.2
  L1 w0.1: U11C.49@68.3,31.675 68.3,32.65 68.75,33.1 75.775,33.1 76.45,32.425 82.25,32.425 82.4,32.275 82.4,31.225 R26C.2@83,30.625 84.47,30.625 P10C.3@88.2,26.895
MCU_INT0: U10F.D15 U11C.2 | length 42.8
  L1 w0.1: U10F.D15@38.828,31.222 v1(39.525,31.222) ; v1(69.575,36) 70.8,36 72.825,33.975 U11C.2@77.6,33.975
  L4 w0.1: v1(39.525,31.222) 40.222,31.222 40.7,31.7 41.15,31.7 41.375,31.475 41.925,31.475 42.775,32.325 46.3,32.325 46.9,32.925 52.275,32.925 53.6,34.25 56.75,34.25 58.075,35.575 63.8,35.575 65.025,34.35 67.925,34.35 v1(69.575,36)
MCU_INT1: U10F.G13 U11C.43 | length 40.2
  L1 w0.1: v1(37.425,34.757) U10F.G13@38.121,34.757 ; U11C.43@66.5,35.975 v1(68.15,35.975)
  L4 w0.1: v1(37.425,34.757) 38.182,34.757 39.025,35.6 40.375,35.6 40.75,35.975 41.15,35.975 41.475,35.65 41.875,35.65 42.15,35.925 42.55,35.925 42.825,35.65 43.275,35.65 43.5,35.875 45.5,35.875 45.825,35.55 47.15,35.55 47.65,35.05 50.675,35.05 53.95,38.325 59.225,38.325 60.425,39.525 65.4,39.525 66.15,38.775 68.375,38.775 68.975,38.175 68.975,36.8 v1(68.15,35.975)
NetC28P_2: C28P.2 U16P.6 | length 4.9
  L1 w0.2: U16P.6@14.77,77.25 14.77,76.53 14.975,76.325 17.87,76.325 C28P.2@18.545,77
NetC39P_1: C39P.1 R29P.1 R30P.2 | length 2.3
  L1 w0.2: R30P.2@18.225,79.125 R29P.1@18.225,81.425
NetC50D_2: C50D.2 R12D.2 R13D.2 | length 2.1
  L1 w0.1: R12D.2@64.599,43.826 65.399,43.826 65.449,43.876 ; R13D.2@65.449,44.676 65.449,43.876 ; C50D.2@65.778,43.547 65.449,43.876
NetD10C_1: D10C.1 R20C.1 | length 1.9
  L1 w0.1: R20C.1@84.175,35.325 D10C.1@86.125,35.325
NetD10F_1: D10F.1 R16F.1 | length 2.2
  L1 w0.1: D10F.1@2,36.95 R16F.1@4.2,36.95
NetD11F_1: D11F.1 R17F.1 | length 2.2
  L1 w0.1: D11F.1@2,65.45 R17F.1@4.25,65.45
NetD11P_2: D11P.2 R32P.2 | length 2.1
  L1 w0.1: D11P.2@2,68.05 R32P.2@4.15,68.05
NetD12F_1: D12F.1 R18F.1 | length 2.3
  L1 w0.1: D12F.1@2.025,60.95 R18F.1@4.325,60.95
NetP12C_4: P12C.4 R18C.1 | length 2.5
  L1 w0.3: R18C.1@83.275,42.325 83.65,41.95 P12C.4@85.575,41.95
NetP12H_4: P12H.4 R39H.1 | length 2.6
  L1 w0.1: R39H.1@72.675,72.325 73.75,73.4 P12H.4@73.75,74.475
NetQ10H_1: Q10H.1 Q11H.3 R16H.2 | length 6.6
  L1 w0.1: Q11H.3@9.375,34.825 9.375,34.025 10.662,32.738 11.662,32.738 R16H.2@12.5,31.9 12.85,32.25 Q10H.1@14.125,32.25
NetQ12H_3: Q12H.3 R18H.1 | length 1.7
  L1 w0.1: R18H.1@12.15,33.775 12.15,35.425 Q12H.3@12.2,35.475
NetQ13H_1: Q13H.1 Q14H.3 R27H.2 | length 10.6
  L1 w0.1: R27H.2@18.65,52.65 18.65,53.4 18.025,54.025 Q14H.3@18.025,55.125 21.775,55.125 23.025,56.375 23.025,57.431 Q13H.1@23.969,58.375
NetQ13H_3: Q13H.3 R32H.2 | length 2.7
  L1 w0.1: v1(21.625,56.525) 21.625,57.375 Q13H.3@21.953,57.703
  L6 w0.1: v1(21.625,56.525) 21.875,56.775 R32H.2@21.875,57.85
NetR10D_2: R10D.2 U10D.L8 | length 3.7
  L6 w0.15: U10D.L8@62.584,52.816 63.151,52.816 63.65,52.317 63.65,51.184 R10D.2@64.599,50.235
NetR11F_1: R11F.1 U10F.F8 | length 1.5
  L1 w0.25: U10F.F8@42.364,37.586 v1(42.364,38.301)
  L6 w0.2: R11F.1@42.375,37.475 v1@42.375,38.29
  L6 w0.25: v1(42.364,38.301) v1@42.375,38.29
NetR14D_2: R14D.2 U11D.L8 | length 3.7
  L1 w0.1: R14D.2@56.609,58.225 57.725,58.225 59.19,56.76 U11D.L8@59.19,56.21
NetR21P_2: R21P.2 U12P.A1 | length 2
  L1 w0.1: U12P.A1@70.375,67.75 71.725,69.1 R21P.2@71.725,69.225
NetR22P_1: R22P.1 U13P.A1 | length 2
  L1 w0.1: U13P.A1@85.875,68.175 87.225,69.525 R22P.1@87.225,69.65
NetU11C_19: U11C.19 Y10C.2 | length 4.9
  L1 w0.1: U11C.19@74.8,42.775 74.8,43.75 75.15,44.1 76.875,44.1 77.2,44.425 Y10C.2@77.2,45.675
NetU11C_20: U11C.20 Y10C.1 | length 2.5
  L1 w0.1: U11C.20@74.3,42.775 Y10C.1@74.3,45.275
OV0_CEC: D17H.1 D17H.10 J12H.13 R26H.1 | length 6.4
  L1 w0.1: J12H.13@54.5,68.64 54.5,66.9 55.35,66.05 D17H.10@55.35,65.313 D17H.1@55.35,64.438 55.35,63.4 54.95,63 R26H.1@54.95,62.75
OV0_CEC_R: R26H.2 U10F.P19 | length 56.9
  L1 w0.1: U10F.P19@28.929,35.464 v1(28.929,36.164) ; v1(54.15,61.95) 54.675,61.95 R26H.2@54.95,61.675
  L4 w0.1: v1(28.929,36.164) 28.929,36.904 29.425,37.4 29.425,37.725 29.175,37.975 29.175,41.225 28.225,42.175 28.225,43.95 28.075,44.1 28.075,60.9 32.35,65.175 38.773,65.175 39.323,64.625 52.475,64.625 54.15,62.95 v1(54.15,61.95)
OV0_DDC_SCL: D17H.2 D17H.9 J12H.15 U10H.11 | length 47.1
  L1 w0.1: J12H.15@55.5,68.64 55.5,66.575 55.85,66.225 D17H.9@55.85,65.313 D17H.2@55.85,64.438 v1(55.85,62.425)
  L4 w0.1: v1(24.65,65.075) 24.025,65.075 22.725,66.375 22.725,66.975 23.175,67.425 27.55,67.425 29.4,65.575 38.939,65.575 39.514,65 53.275,65 v1(55.85,62.425)
  L6 w0.1: U10H.11@24.65,62.775 v1(24.65,65.075)
OV0_DDC_SCL_LV: U10F.W17 U10H.10 | length 26.2
  L1 w0.1: v1(26.125,41.825) 26.808,41.142 U10F.W17@26.808,40.414
  L4 w0.1: v1(25.3,64.225) 25.3,62.15 26.275,61.175 26.275,46.525 25.85,46.1 25.85,42.475 26.125,42.2 v1(26.125,41.825)
  L6 w0.1: U10H.10@25.3,62.775 v1(25.3,64.225)
OV0_DDC_SDA: D17H.4 D17H.7 J12H.16 Q16H.3 R35H.2 | length 19.8
  L1 w0.1: J12H.16@56,68.64 56,67.2 56.275,66.925 56.45,66.925 56.85,66.525 D17H.7@56.85,65.313 D17H.4@56.85,64.438 56.85,63.575 57.575,62.85 58.475,62.85 59.325,63.7 61.5,63.7 62.125,64.325 62.125,66.825 64.4,69.1 Q16H.3@64.4,71.5
OV0_DDC_SDA_LV: Q16H.2 R36H.2 U10F.R17 | length 73.6
  L1 w0.1: v1(29.636,36.886) U10F.R17@29.636,37.586 ; v1(62.425,73.4) Q16H.2@63.45,73.4 63.45,74.7 R36H.2@63.925,75.175
  L4 w0.1: v1(29.636,36.886) 29.625,36.897 29.625,37.25 29.7,37.325 29.7,38.625 29.475,38.85 29.475,41.3 28.6,42.175 28.6,44.15 28.425,44.325 28.425,46.6 28.525,46.7 28.525,60.714 32.536,64.725 38.5,64.725 39.025,64.2 50.8,64.2 53.575,61.425 56.525,61.425 58.425,63.325 58.425,63.875 62.425,67.875 v1(62.425,73.4)
OV0_HDMI_HPD: D17H.5 D17H.6 J12H.19 R29H.1 R33H.1 U10H.9 | length 54.7
  L1 w0.1: J12H.19@57.5,68.64 57.5,66.175 57.35,66.025 D17H.6@57.35,65.313 D17H.5@57.35,64.438 57.35,63.8 v1(57.7,63.45) 58.425,63.45 58.975,64 R33H.1@58.975,64.525 R29H.1@58.975,65.7
  L4 w0.1: v1(25.95,65.075) 25.4,65.075 24.95,64.625 22.55,64.625 22.075,65.1 22.075,66.825 23.05,67.8 28.025,67.8 29.8,66.025 39.125,66.025 39.775,65.375 55.775,65.375 v1(57.7,63.45)
  L6 w0.1: U10H.9@25.95,62.775 v1(25.95,65.075)
OV0_HDMI_HPD_LV: U10F.V17 U10H.8 | length 26.7
  L1 w0.1: U10F.V17@27.515,39.707 v1(27.515,40.407)
  L4 w0.1: v1(26.6,64.225) 26.6,46.3 26.125,45.825 26.125,42.55 26.875,41.8 26.875,41.047 v1(27.515,40.407)
  L6 w0.1: U10H.8@26.6,62.775 v1(26.6,64.225)
OV0_P5V: J12H.18 R29H.2 R35H.1 | length 16.1
  L1 w0.1: R29H.2@60.175,65.7 60.175,66.25 58.425,68 58.425,70.7 v1(57.8,71.325) 58.325,71.85 61.05,71.85 R35H.1@63.15,69.75
  L1 w0.2: J12H.18@57,68.64 57,70.525 v1(57.8,71.325)
OV0_TMDS0_N: D18H.4 D18H.7 J12H.9 R22H.3 U10F.AB18 | length 51.1
  L1 w0.1: U10F.AB18@23.979,41.828 24.191,41.616 24.191,41.475 24.086,41.37 23.872,41.37 22.96,42.282 22.96,42.74 23.01,42.79 23.01,49.725 32.435,59.15 48.849,59.15 52.175,62.476 52.175,63.925 52.275,64.025 D18H.7@52.275,64.413 D18H.4@52.275,65.287 52.275,65.675 52.175,65.775 52.175,66.6 52.15,66.625 52.15,66.94 52.5,67.29 J12H.9@52.5,68.64
  L6 w0.1: R22H.3@23.2,43.8 23.2,43.1 v1(23.21,43.09)
OV0_TMDS0_P: D18H.5 D18H.6 J12H.7 R22H.4 U10F.AA18 | length 51.6
  L1 w0.1: U10F.AA18@24.686,41.121 24.474,41.333 24.333,41.333 24.169,41.17 23.789,41.17 23.52,41.44 22.76,42.199 22.76,42.74 22.71,42.79 22.71,49.85 32.31,59.45 48.725,59.45 51.875,62.6 51.875,63.925 51.775,64.025 D18H.6@51.775,64.413 D18H.5@51.775,65.287 51.775,65.675 51.875,65.775 51.875,66.476 51.85,66.501 51.85,66.94 51.5,67.29 J12H.7@51.5,68.64
  L6 w0.1: v1(22.51,43.08) 22.55,43.12 R22H.4@22.55,43.8
OV0_TMDS1_N: D19H.1 D19H.10 J12H.6 R21H.3 U10F.AA19 | length 53.4
  L1 w0.1: v1(23.979,39.714) U10F.AA19@23.979,40.414 23.413,40.414 21.87,41.958 21.87,42.295 21.925,42.35 21.925,51.115 31.71,60.9 48.174,60.9 50.225,62.951 50.225,63.925 50.325,64.025 D19H.10@50.325,64.413 D19H.1@50.325,65.287 50.325,65.675 50.225,65.775 50.225,66.175 50.675,66.625 50.675,66.95 51,67.275 J12H.6@51,68.64
  L6 w0.1: R21H.3@23.703,40.463 23.505,40.463 23.422,40.38 23.422,39.85 23.558,39.714 v1(23.979,39.714)
OV0_TMDS1_P: D19H.2 D19H.9 J12H.4 R21H.4 U10F.AB20 | length 53.7
  L1 w0.1: v1(22.565,39.714) U10F.AB20@22.565,40.414 22.759,40.22 22.93,40.22 23.02,40.31 23.02,40.525 21.67,41.875 21.67,42.305 21.625,42.35 21.625,51.239 31.586,61.2 48.05,61.2 49.925,63.075 49.925,63.925 49.825,64.025 D19H.9@49.825,64.413 D19H.2@49.825,65.287 49.825,65.675 49.925,65.775 49.925,66.299 50.375,66.749 50.375,66.95 50,67.325 J12H.4@50,68.64
  L6 w0.1: v1(22.565,39.714) 22.987,39.714 23.122,39.85 23.122,40.504 23.243,40.625 R21H.4@23.243,40.923
OV0_TMDS2_N: D19H.4 D19H.7 J12H.3 R19H.2 U10F.AB21 | length 53.9
  L1 w0.1: v1(21.858,39.007) U10F.AB21@21.858,39.707 21.413,39.707 21.32,39.8 21.32,39.955 21.178,40.097 21.023,40.097 20.825,40.295 20.825,40.475 21,40.65 21,40.925 20.825,41.1 20.825,52.313 31.037,62.525 47.874,62.525 48.725,63.376 48.725,63.925 48.825,64.025 D19H.7@48.825,64.413 D19H.4@48.825,65.287 48.825,65.675 48.725,65.775 48.725,66.151 49.15,66.576 49.15,66.94 49.5,67.29 J12H.3@49.5,68.64
  L6 w0.1: v1(21.858,39.007) 21.858,38.512 22.139,38.232 22.427,38.232 R19H.2@22.64,38.02
OV0_TMDS2_P: D19H.5 D19H.6 J12H.1 R19H.1 U10F.AB22 | length 53.9
  L1 w0.1: v1(21.151,38.3) U10F.AB22@21.151,39 21.151,39.545 20.525,40.171 20.525,52.437 30.913,62.825 47.75,62.825 48.425,63.5 48.425,63.925 48.325,64.025 D19H.6@48.325,64.413 D19H.5@48.325,65.287 48.325,65.675 48.425,65.775 48.425,66.275 48.85,66.7 48.85,66.94 48.5,67.29 J12H.1@48.5,68.64
  L6 w0.1: v1(21.151,38.3) 21.646,38.3 21.968,37.978 21.968,37.772 R19H.1@22.18,37.56
OV0_TMDS3_N: D18H.1 D18H.10 J12H.12 R25H.2 U10F.Y18 | length 54.8
  L1 w0.1: v1(26.093,40.414) U10F.Y18@25.393,40.414 25.181,40.202 25.04,40.202 24.92,40.322 24.92,40.5 25.349,40.929 25.349,41.308 24.16,42.496 24.16,43.19 24.21,43.24 24.21,48.486 33.149,57.425 49.599,57.425 53.675,61.501 53.675,63.925 53.775,64.025 D18H.10@53.775,64.413 D18H.1@53.775,65.287 53.775,65.675 53.675,65.775 53.675,66.6 53.65,66.625 53.65,66.94 54,67.29 J12H.12@54,68.64
  L6 w0.1: v1(26.093,40.414) 26.093,39.919 26.31,39.702 26.31,39.126 26.02,38.836 26.02,38.49 R25H.2@26.2,38.31
OV0_TMDS3_P: D18H.2 D18H.9 J12H.10 R25H.1 U10F.Y19 | length 54.7
  L1 w0.1: v1(25.386,39.707) U10F.Y19@24.686,39.707 24.898,39.919 24.898,40.061 24.72,40.239 24.72,40.583 25.149,41.011 25.149,41.225 24.987,41.387 23.96,42.413 23.96,43.19 23.91,43.24 23.91,48.61 33.025,57.725 49.475,57.725 53.375,61.625 53.375,63.925 53.275,64.025 D18H.9@53.275,64.413 D18H.2@53.275,65.287 53.275,65.675 53.375,65.775 53.375,66.476 53.35,66.501 53.35,66.94 53,67.29 J12H.10@53,68.64
  L6 w0.1: v1(25.386,39.707) 25.881,39.707 26.01,39.578 26.01,39.25 25.72,38.96 25.72,38.48 R25H.1@25.55,38.31
# Altium PCB netv2mvp-dvt1a.PCBDOC (part 6 of 6)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 90 x 100 mm, 6 copper layers (L1, L2, L3, L4, L5, L6), stack 1.542 mm thick; 329 components, 277 nets, 2092 pads, 848 vias.

## Via types
v1: diameter 0.5, hole 0.25, L1 to L6, tented both sides, 789 vias
v2: diameter 0.45, hole 0.25, L1 to L6, tented both sides, 57 vias
v3: diameter 0.5, hole 0.25, L1 to L6, tented top, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
TX1_CLK_P: D22H.2 D22H.9 P10H.12 U10F.G22 | length 67.3
  L1 w0.1: v1(31.757,27.694) U10F.G22@31.757,28.393 ; P10H.12@34,73.75 34,74.3 34.05,74.35 34.05,74.774 34.45,75.174 v1@34.45,75.875 ; v1(34.975,68.2) 35.075,68.3 D22H.9@35.075,69.013 D22H.2@35.075,69.888
  L3 w0.1: v1(31.757,27.694) 31.757,28.143 31.55,28.35 27.5,28.35 26.8,29.05 26.8,29.396 19.54,36.656 19.54,43.89 35.175,59.525 35.175,68 v1(34.975,68.2) ; v1(34.25,75.875) 34.45,75.675 34.45,73.551 35.175,72.826 v1@35.175,68.2
TX1_HDMI_5V: D20H.1 F11H.2 P10H.19 | length 10.2
  L1 w0.2: P10H.19@35.4,72.525 35.4,72.4 35.75,72.05 37.2,72.05 v1(37.65,71.6)
  L6 w0.2: D20H.1@31.7,69.45 F11H.2@35.1,69.45 35.1,70.6 36.1,71.6 v1(37.65,71.6)
TX1_HPD: D21H.5 D21H.6 P10H.1 R40H.2 U10H.1 | length 24.9
  L1 w0.1: v1(31.05,72.175) 31.4,72.525 P10H.1@31.8,72.525 ; D21H.5@39.325,69.013 D21H.6@39.325,69.888 v1(39.325,71.963) R40H.2@39.325,72.75
  L4 w0.1: v1(31.05,72.175) 31.525,72.65 34.675,72.65 35.175,72.15 38.075,72.15 38.262,71.963 v1(39.325,71.963)
  L6 w0.1: U10H.1@22.7,68.475 22.7,71.275 23.075,71.65 30.525,71.65 v1(31.05,72.175)
TX1_HPD_LL: U10F.U18 U10H.2 | length 35
  L1 w0.1: U10F.U18@27.515,38.293 v1(28.214,38.293)
  L4 w0.1: v1(23.35,66.95) 24.1,66.2 26.15,66.2 27.025,65.325 27.025,46.3 26.4,45.675 26.4,42.9 27.2,42.1 27.2,41.287 27.975,40.512 27.975,40.3 27.55,39.875 27.55,39.575 27.975,39.15 27.975,38.532 v1(28.214,38.293)
  L6 w0.1: v1(23.35,66.95) U10H.2@23.35,68.475
TX1_SCL: D21H.2 D21H.9 P10H.17 Q18H.3 R43H.2 | length 19.9
  L1 w0.1: P10H.17@35,72.525 35,72 35.2,71.8 36.675,71.8 37.825,70.65 D21H.9@37.825,69.888 D21H.2@37.825,69.013 v1(37.825,67.325) ; v1(40.425,75.75) Q18H.3@41.675,75.75 41.675,76.25 41.075,76.85 R43H.2@41.075,77.4
  L3 w0.1: v1(37.825,67.325) 37.825,71.05 38.3,71.525 38.3,73.625 v1(40.425,75.75)
TX1_SCL_LV: Q18H.2 R44H.2 U10F.P16 | length 55
  L1 w0.1: v1(31.05,36.886) U10F.P16@31.05,37.586 ; v1(43.575,73.85) Q18H.2@42.625,73.85 42.625,72.575 R44H.2@42.175,72.125 43.275,72.125 44.25,71.15 44.25,67.7 44.9,67.05 v1@44.9,63.7
  L4 w0.1: v1(31.05,36.886) 31.05,37.675 31.575,38.2 31.575,39.9 30.55,40.925 30.55,41.35 30.75,41.55 30.75,42.15 29.8,43.1 29.8,43.45 30.1,43.75 30.1,44.15 29.935,44.315 29.935,47.465 29.525,47.875 29.525,59.5 33.05,63.025 44.35,63.025 v1(44.925,63.6)
TX1_SDA: D21H.4 D21H.7 P10H.18 Q17H.3 R41H.2 | length 14.5
  L1 w0.1: P10H.18@35.2,73.75 35.5,73.75 35.725,73.525 35.725,72.95 36.35,72.325 37.775,72.325 38.825,71.275 D21H.7@38.825,69.888 D21H.4@38.825,69.013 38.825,68.05 39.45,67.425 40.275,67.425 41.275,68.425 Q17H.3@42.5,68.425 42.5,68.85 41.875,69.475 R41H.2@41.875,70.1
TX1_SDA_LV: Q17H.2 R42H.2 U10F.R16 | length 41.8
  L1 w0.1: U10F.R16@30.343,38.293 v1(31.043,38.293) ; v1(43.05,63.65) R42H.2@43.05,64.8 43.45,65.2 Q17H.2@43.45,66.525
  L4 w0.1: v1(31.043,38.293) 31.043,38.857 30.125,39.775 30.125,41.4 29.225,42.3 29.225,45.125 29.675,45.575 29.675,46.9 29.2,47.375 29.2,59.7 32.925,63.425 37.975,63.425 38.2,63.65 v1(43.05,63.65)
TX1_TMDS0_N: D22H.4 D22H.7 P10H.11 U10F.E22 | length 70.1
  L1 w0.1: v1(33.172,26.279) U10F.E22@33.172,26.979 ; P10H.11@33.8,72.525 33.8,72.05 33.75,72 33.75,71.325 33.975,71.1 33.975,70.375 34.075,70.275 D22H.4@34.075,69.888 D22H.7@34.075,69.013 34.075,68.625 33.975,68.525 v1@33.975,67.25
  L3 w0.1: v1(33.172,26.279) 33.172,25.784 31.507,24.12 21.79,24.12 18.055,27.855 18.055,44.201 33.975,60.121 33.975,67.05 v1(34.175,67.25)
TX1_TMDS0_P: D22H.5 D22H.6 P10H.9 U10F.D22 | length 70.8
  L1 w0.1: P10H.9@33.4,72.525 33.4,72.05 33.45,72 33.45,71.201 33.675,70.976 33.675,70.375 33.575,70.275 D22H.5@33.575,69.888 D22H.6@33.575,69.013 33.575,68.625 33.675,68.525 v1@33.675,67.25 ; v1(33.879,25.572) U10F.D22@33.879,26.272
  L3 w0.1: v1(33.475,67.25) 33.675,67.05 33.675,60.246 17.755,44.326 17.755,27.731 21.666,23.82 31.631,23.82 33.384,25.572 v1(33.879,25.572)
TX1_TMDS1_N: D23H.1 D23H.10 P10H.8 U10F.C22 | length 82.2
  L1 w0.1: D23H.1@32.15,69.888 D23H.10@32.15,69.013 32.15,68.3 v1(32.25,68.2) ; v1@33.15,75.875 33.15,74.35 33.2,74.3 P10H.8@33.2,73.75 ; v1(34.586,24.865) U10F.C22@34.586,25.565
  L3 w0.1: v1@32.05,68.2 32.05,72.126 33.15,73.226 33.15,75.675 v1(33.35,75.875) ; v1(32.25,68.2) 32.05,68 32.05,60.919 16.39,45.259 16.39,26.55 20.55,22.39 32.606,22.39 34.586,24.37 v1(34.586,24.865)
TX1_TMDS1_P: D23H.2 D23H.9 P10H.6 U10F.B22 | length 83
  L1 w0.1: v1(31.55,68.2) 31.65,68.3 D23H.9@31.65,69.013 D23H.2@31.65,69.888 ; P10H.6@32.8,73.75 32.8,74.3 32.85,74.35 v1@32.85,75.875 ; v1(35.293,24.158) U10F.B22@35.293,24.858
  L3 w0.1: v1(31.55,68.2) 31.75,68 31.75,61.043 16.09,45.383 16.09,26.426 20.426,22.09 32.73,22.09 34.798,24.158 v1(35.293,24.158) ; v1@31.75,68.2 31.75,72.25 32.85,73.35 32.85,75.675 v1(32.65,75.875)
TX1_TMDS2_N: D23H.4 D23H.7 P10H.5 U10F.B21 | length 82.5
  L1 w0.1: v1@30.55,67.25 30.55,68.525 30.65,68.625 D23H.7@30.65,69.013 D23H.4@30.65,69.888 30.65,70.275 30.55,70.375 30.55,70.8 30.95,71.2 32.224,71.2 32.55,71.526 32.55,72 32.6,72.05 P10H.5@32.6,72.525 ; v1(36,24.865) U10F.B21@36,25.565
  L3 w0.1: v1(30.75,67.25) 30.55,67.05 30.55,61.54 14.63,45.62 14.63,23.7 17.57,20.76 32.4,20.76 35.35,23.71 35.41,23.71 35.745,24.044 35.745,24.115 36,24.37 v1(36,24.865)
TX1_TMDS2_P: D23H.5 D23H.6 P10H.3 U10F.A21 | length 83.3
  L1 w0.1: v1@30.25,67.25 30.25,68.525 30.15,68.625 D23H.6@30.15,69.013 D23H.5@30.15,69.888 30.15,70.275 30.25,70.375 30.25,70.924 30.826,71.5 32.1,71.5 32.25,71.65 32.25,72 32.2,72.05 P10H.3@32.2,72.525 ; v1(36.707,24.158) U10F.A21@36.707,24.858
  L3 w0.1: v1(30.05,67.25) 30.25,67.05 30.25,61.664 14.33,45.744 14.33,23.576 17.446,20.46 32.524,20.46 35.552,23.487 35.552,23.568 35.886,23.903 35.957,23.903 36.212,24.158 v1(36.707,24.158)
TX_HDMI_5V: D13H.1 F10H.2 J10H.18 Q13H.2 R27H.1 | length 30
  L1 w0.2: R27H.1@17.45,52.65 17.45,54.05 16.975,54.525 16.975,55.725 19.25,58 20.907,58 Q13H.2@22.625,59.718
  L1 w0.3: v1(7.85,52.45) 8.3,52 J10H.18@10.16,52 ; R27H.1@17.45,52.65 17.5,52.6 v1(17.5,51.725)
  L6 w0.3: v1(7.85,52.45) 9.025,52.45 10.55,50.925 13.925,50.925 16.7,50.925 v1(17.5,51.725) ; D13H.1@18.3,48.2 18.3,50.925 v1(17.5,51.725) ; F10H.2@18.3,52.9 18.3,52.525 v1(17.5,51.725)
UART0_RX: P11C.7 R25C.1 U10F.E13 U11C.39 | length 63.9
  L1 w0.1: v1(39.536,32.647) U10F.E13@39.536,33.343 ; U11C.39@66.5,37.975 v1(68.15,37.975) ; P11C.7@69.01,25.23 70.455,26.675 74.9,26.675 75.275,27.05 75.275,28.5 78.6,31.825 R25C.1@81.8,31.825
  L3 w0.1: v1(68.15,37.975) 69.075,37.05 69.075,32.975 67.925,31.825 67.925,26.315 P11C.7@69.01,25.23
  L4 w0.1: v1(39.536,32.647) 40.222,32.647 41.1,33.525 42.55,33.525 42.875,33.85 45.875,33.85 46.2,33.525 50.5,33.525 52.3,35.325 53.575,35.325 54.075,35.825 56.175,35.825 57.038,36.688 61.737,36.688 63.025,37.975 v1(68.15,37.975)
UART0_TX: P11C.9 R26C.1 U10F.E14 U11C.40 | length 65.5
  L1 w0.1: v1(38.828,31.94) U10F.E14@38.828,32.636 ; v1(64.85,37.475) U11C.40@66.5,37.475 ; P11C.9@66.47,25.23 67.675,24.025 69.575,24.025 70.275,24.725 70.275,25.85 70.775,26.35 75.15,26.35 75.625,26.825 75.625,28.35 77.9,30.625 R26C.1@81.8,30.625
  L3 w0.1: v1(64.85,37.475) 65.725,37.475 67.55,35.65 67.55,26.31 P11C.9@66.47,25.23
  L4 w0.1: v1(38.828,31.94) 39.54,31.94 39.95,32.35 40.5,32.35 40.7,32.15 41.175,32.15 41.775,32.75 43.675,32.75 44.45,33.525 45.8,33.525 46.1,33.225 51.675,33.225 52.725,34.275 53.175,34.275 54.4,35.5 56.3,35.5 57.1,36.3 62.025,36.3 63.2,37.475 v1(64.85,37.475)
USB0_N: R15C.2 U11C.6 | length 18.3
  L1 w0.1: v1@75.4,35.825 76.5,35.825 76.65,35.975 U11C.6@77.6,35.975 ; v1@82.3,33.725 82.3,34.35 R15C.2@82.8,34.85
  L6 w0.1: v1(75.4,36.025) 75.2,35.825 74.067,35.825 73.4,35.158 73.4,33.642 74.942,32.1 81.558,32.1 81.733,32.275 81.733,32.3 82.3,32.867 82.3,33.5 v1(82.5,33.7)
USB0_P: R14C.2 U11C.5 | length 17.3
  L1 w0.1: v1@75.4,35.625 76.5,35.625 76.65,35.475 U11C.5@77.6,35.475 ; R14C.2@81.6,34.85 82.1,34.35 v1@82.1,33.725
  L6 w0.1: v1(75.4,35.425) 75.2,35.625 74.15,35.625 73.6,35.075 73.6,33.725 75.025,32.3 81.475,32.3 81.475,32.325 82.1,32.95 82.1,33.5 v1(81.9,33.7)
USBD_N: P12C.2 R15C.1 | length 7.6
  L1 w0.1: R15C.1@82.8,36.05 82.3,36.55 82.3,36.925 83.125,37.75 83.125,40.25 83.775,40.9 84.4,40.9 84.65,40.65 P12C.2@85.575,40.65
USBD_P: P12C.3 R14C.1 | length 7.9
  L1 w0.1: R14C.1@81.6,36.05 82.1,36.55 82.1,37.008 82.925,37.833 82.925,40.333 83.692,41.1 84.45,41.1 84.65,41.3 P12C.3@85.575,41.3
USBVDD: C11C.1 C12C.1 R17C.1 U11C.7 | length 9.4
  L1 w0.3: v1(75.3,37.5) 75.3,37.175 76,36.475 U11C.7@77.6,36.475 79,36.475 80.075,37.55 C12C.1@80.2,37.55
  L6 w0.3: v1(75.3,37.5) R17C.1@75.3,38.5 75.65,38.85 C11C.1@77.575,38.85
  other v1: 79.625,37.1
VREG_OPT: C13C.1 R19C.1 U11C.8 | length 5.5
  L1 w0.3: U11C.8@77.6,36.975 78.675,36.975 79.025,37.325 v1(79.025,38.05) 79.025,38.3 79.425,38.7 R19C.1@79.95,38.7
  L6 w0.3: C13C.1@77.575,36.95 77.925,36.95 v1(79.025,38.05)
VTT: C13D.1 C20D.1 C26D.1 C27D.2 C28D.1 C29D.2 C30P.1 C33D.2 C34D.2 C35D.2 C42D.2 C43D.2 RP10D.1 RP10D.2 RP10D.3 RP10D.4 RP11D.1 RP11D.2 RP11D.3 RP11D.4 RP12D.1 RP12D.2 RP12D.3 RP12D.4 RP13D.1 RP13D.2 RP13D.3 RP13D.4 RP14D.1 RP14D.2 RP14D.3 RP14D.4 RP15D.1 RP15D.2 RP15D.3 RP15D.4 U15P.3 U15P.5 | length 72.6
  L1 w0.2: C35D.2@65.448,46.133 v1(65.925,45.656) 66.306,45.276 ; RP11D.1@66.164,46.637 66.551,46.25 v1(66.875,46.25) ; RP11D.2@66.615,47.088 67.15,46.553 67.15,46.525 ; RP11D.3@66.968,47.442 67.51,46.9 67.525,46.9 ; C20D.1@67.276,45.276 67.276,45.85 v1(66.875,46.25) ; RP11D.4@67.419,47.892 67.8,47.511 v1(67.8,47.175) 67.525,46.9 ; C27D.2@67.923,48.608 v1(68.4,48.131) ; RP13D.1@68.639,49.112 69.026,48.725 v1(69.35,48.725) ; RP13D.2@69.09,49.563 69.615,49.037 69.662,49.037 ; RP13D.3@69.443,49.916 69.985,49.375 70,49.375 ; RP13D.4@69.894,50.367 70.275,49.986 v1(70.275,49.65) ; v1@70.137,49.512 70.237,49.512 C26D.1@70.879,48.87 ; C29D.2@70.398,51.083 v1(70.875,50.606) ; RP15D.1@71.114,51.587 71.501,51.2 v1(71.825,51.2) ; RP15D.2@71.564,52.038 72.112,51.49 72.112,51.487 ; RP15D.3@71.918,52.391 72.45,51.859 72.45,51.85 ; RP15D.4@72.369,52.842 72.75,52.461 v1(72.75,52.125) ; 72.375,51.75 72.424,51.75 C28D.1@73.079,51.095 ; C34D.2@72.873,53.558 v1@73.3,53.131 ; U15P.3@74.816,58.666 75.225,58.256 75.225,58.125 75.5,57.85 75.7,57.85 77.141,56.409 C30P.1@77.284,56.409 ; U15P.5@75.381,59.231 v1(75.825,59.675) ; v1(66.875,46.25) 67.15,46.525 ; 67.15,46.525 67.525,46.9
  L1 w0.25: C13D.1@73.675,54.15 73.688,54.138 v1(74.181,53.644) ; C13D.1@74.275,54.725 v1(74.781,54.219) ; C30P.1@77.475,56.25 v1(77.981,55.744)
  L1 w0.5: C20D.1@67.276,45.276 66.306,45.276 v1(65.925,45.656) 66.281,45.656 v1(66.875,46.25) v1(69.35,48.725) 69.662,49.037 70,49.375 70.137,49.512 v1(70.275,49.65) v1(71.825,51.2) 72.112,51.487 72.375,51.75 v1(72.75,52.125) 73.35,52.725 v1(73.35,53.081) ; v1@73.3,53.131 73.3,53.75 73.688,54.138 74.275,54.725 74.6,55.05 v1(75.39,55.05) 76.125,55.05 v1(76.644,55.569) 77.15,56.075 77.284,56.209 C30P.1@77.284,56.409
  L3 w0.2: v1(68.4,48.131) 68.4,49.25 76.35,57.2 76.35,58.6 75.825,59.125 v1(75.825,59.675)
  L6 w0.2: C33D.2@65.448,46.133 v1(65.925,45.656) ; RP10D.4@66.164,46.637 66.551,46.25 v1(66.875,46.25) v1(67.8,47.175) 67.8,47.511 RP10D.1@67.419,47.892 ; RP10D.3@66.615,47.088 67.15,46.552 ; RP10D.2@66.968,47.442 67.51,46.9 ; C42D.2@67.923,48.608 v1(68.4,48.131) ; RP12D.4@68.639,49.112 69.026,48.725 v1(69.35,48.725) v1(70.275,49.65) 70.275,49.986 RP12D.1@69.894,50.367 ; RP12D.3@69.09,49.563 69.625,49.027 ; RP12D.2@69.443,49.916 69.984,49.375 ; C43D.2@70.398,51.083 v1(70.875,50.606) ; RP14D.4@71.114,51.587 71.501,51.2 v1(71.825,51.2) v1(72.75,52.125) 72.75,52.461 RP14D.1@72.369,52.842 ; RP14D.3@71.564,52.038 72.1,51.502 ; RP14D.2@71.918,52.391 72.459,51.85
VTT_REF: C10D.2 C11D.1 C12D.1 C13F.1 C14F.1 C18F.1 C19F.1 C30D.2 C31D.1 C31P.1 C32D.1 U10D.H1 U10D.M8 U10F.E3 U10F.N3 U10F.V3 U10F.W7 U11D.H1 U11D.M8 U15P.6 | length 215.9
  L1 w0.1: v1(54.7,59.425) 54.7,58.675 55.225,58.15 56.05,58.15 56.832,58.932 C31D.1@57.316,58.932 58.165,58.932 59.756,57.341 U11D.M8@59.756,56.775 ; U11D.H1@61.453,50.553 62.072,50.553 63.115,49.51 ; C12D.1@63.115,48.82 63.115,49.51 ; v1(64.775,51.473) 64.401,51.099 C30D.2@64.401,49.901 63.505,49.901 63.115,49.51
  L1 w0.2: U10F.V3@37.414,49.607 v1(37.414,50.298) ; U10F.N3@40.95,46.071 40.952,46.069 v1(40.952,45.377) ; U15P.6@74.01,60.603 74.728,61.321 C31P.1@74.728,61.347 ; v1(74.225,61.85) 74.25,61.825 C31P.1@74.728,61.347 ; 74.725,61.825 74.728,61.822 C31P.1@74.728,61.347
  L1 w0.25: U10F.W7@33.879,47.485 v1(33.879,48.2) ; v1(45.892,40.414) U10F.E3@46.607,40.414
  L1 w0.5: v1(73.325,61.85) 73.35,61.825 74.25,61.825 74.725,61.825 v1(75.25,61.825)
  L3 w0.2: v1(33.879,48.2) 33.175,48.2 32.625,48.75 31.775,48.75 30.85,47.825 30.85,44.875 33.7,42.025 34.05,42.025 34.325,42.3 34.825,42.3 35.825,41.3 36.15,41.3 36.475,41.625 36.925,41.625 37.925,40.625 38.35,40.625 38.625,40.9 39.05,40.9 39.425,40.525 39.7,40.525 ; 42.325,40.425 41.1,39.2 40.75,39.2 39.7,40.25 39.7,40.525 ; v1(45.892,40.414) 45.136,40.414 ; 39.7,40.525 40.987,41.812 ; 40.75,43.1 41.075,43.1 41.1,43.125 ; 40.75,43.1 40.4,42.75 40.4,42.4 40.987,41.812 ; 40.75,43.1 40.75,43.4 ; 40.75,43.4 40.775,43.425 41.1,43.425 ; 40.75,43.4 40.4,43.75 40.4,44.175 40.952,44.727 v1(40.952,45.377) 41.55,44.779 41.55,43.875 41.1,43.425 ; 40.987,41.812 41.425,41.375 41.425,41.325 41.8,40.95 ; 41.1,43.125 41.1,43.425 ; 41.1,43.125 42.225,42 42.225,41.7 41.8,41.275 41.8,40.95 ; 41.8,40.95 43.075,39.675 ; 43.075,39.675 44.3,40.9 44.65,40.9 45.136,40.414 ; 43.075,39.675 43.55,39.2 43.922,39.2 45.136,40.414
  L4 w0.3: v1(54.7,59.425) 55.725,60.45 59.9,60.45 61,61.55 63.225,61.55 64.1,60.675 70.7,60.675 71.875,61.85 v1(73.325,61.85) v1(74.225,61.85)
  L6 w0.1: v1(54.7,59.425) 55.025,59.1 55.025,58.325 55.35,58 C10D.2@56.025,58 ; 63.719,53.381 64.374,52.726 64.374,52.723 64.775,52.322 64.775,52.1
  L6 w0.15: C11D.1@55.195,56.74 56.035,56.74 ; C10D.2@56.035,58.01 56.035,56.74 ; U10D.H1@56.927,55.078 56.927,55.848 56.035,56.74 ; 64.775,52.1 v1(64.775,51.473) C32D.1@65.307,50.942
  L6 w0.18: U10D.M8@63.15,53.381 63.719,53.381
  L6 w0.2: v1(33.879,48.2) 33.875,48.204 C13F.1@33.875,48.9 35.45,50.475 35.45,51.875 35.8,52.225 35.8,52.625 35.475,52.95 35.475,53.45 35.725,53.7 36.425,53.7 37.75,52.375 ; 37.4,52 37.453,51.947 C14F.1@37.453,51.278 37.453,50.337 v1(37.414,50.298) ; C19F.1@40.172,43.872 40.952,44.652 v1(40.952,45.377) ; v1(45.892,40.414) 45.922,40.383 C18F.1@45.922,39.747 ; C32D.1@65.307,50.942 65.867,50.942 68.3,53.375 68.3,54.275 71.625,57.6 71.625,58.025 74.225,60.625 v1(74.225,61.85)
  L6 w0.5: 37.4,52 38.367,52.967 47.067,52.967 54.35,60.25 55.65,60.25 59.175,63.775 60.225,63.775 63.325,60.675 70.675,60.675 71.85,61.85 v1(73.325,61.85) v1(74.225,61.85) 75.925,61.85 78.425,59.35 78.425,57.875 77.275,56.725 76.325,56.725 76.025,56.425 76.025,54.125 72.775,50.875 72.775,49.3 69.4,45.925 68.15,45.925 66.925,44.7 61.275,44.7 60.525,43.95 54.575,43.95 52.325,41.7 48.975,41.7 48.475,41.2 46.677,41.2 v1(45.892,40.414)
VUSB: C11H.1 P12C.1 P12H.1 R19C.2 R28P.2 | length 58.1
  L1 w0.3: P12H.1@75.7,74.475 75.7,73.45 76.875,72.275 77.225,72.275 C11H.1@78.325,71.175 79.875,71.175 R28P.2@80.15,71.45 ; R19C.2@81.15,38.7 v1(82.125,38.7) ; v1(84.025,40) P12C.1@85.575,40
  L3 w0.5: v1(76.85,72.3) 77.65,73.1 86.9,73.1 89.175,70.825 89.175,61.55 85.65,58.025 85.65,46.45 84.025,44.825 v1(84.025,40)
  L6 w0.5: v1(82.125,38.7) 83.425,40 v1(84.025,40)
WAKE#: P13H.B11 U10F.E19 | length 36.6
  L1 w0.1: U10F.E19@35.293,29.101 v1(35.993,29.101) ; v1(54.9,7.55) 55.65,6.8 P13H.B11@55.65,3.5
  L6 w0.1: v1(35.993,29.101) 35.993,28.432 36.725,27.7 40.45,27.7 41.325,26.825 41.325,25.175 42,24.5 42,24.325 44.175,22.15 44.175,22.05 51.05,15.175 51.05,11.4 v1(54.9,7.55)
pads on no net: J10H.14 J11H.14 J11H.18 J12H.14 JP10P.0 P10H.2 P11C.2 P11C.4 P11C.6 P11C.18 P11C.20 P13H.A5 P13H.A6 P13H.A7 P13H.A8 P13H.A9 P13H.A10 P13H.A19 P13H.A32 P13H.B8 P13H.B9 P13H.B10 P13H.B12 P13H.B30 RP14D.8 SW10C.4 U10D.J1 U10D.J9 U10D.L1 U10D.L9 U10D.M7 U10D.T7 U10F.AA4 U10F.AA5 U10F.AA6 U10F.AA8 U10F.AA9 U10F.AA10 U10F.AA11 U10F.AA13 U10F.AA14 U10F.AA15 U10F.AA16 U10F.AA20 U10F.AA21 U10F.AB6 U10F.AB7 U10F.AB8 U10F.AB10 U10F.AB11 U10F.AB12 U10F.AB13 U10F.AB15 U10F.AB16 U10F.AB17 U10F.C13 U10F.C20 U10F.D14 U10F.D16 U10F.D17 U10F.D21 U10F.E16 U10F.E17 U10F.E21 U10F.F4 U10F.F15 U10F.F16 U10F.F18 U10F.F19 U10F.F21 U10F.G4 U10F.G15 U10F.G16 U10F.G17 U10F.G18 U10F.H13 U10F.H14 U10F.H15 U10F.H17 U10F.H18 U10F.H19 U10F.H20 U10F.J14 U10F.J15 U10F.J16 U10F.J17 U10F.K13 U10F.K14 U10F.K16 U10F.K17 U10F.K18 U10F.K19 U10F.L4 U10F.L6 U10F.L13 U10F.L14 U10F.L15 U10F.L16 U10F.L18 U10F.M13 U10F.M15 U10F.M16 U10F.M17 U10F.M18 U10F.M20 U10F.N13 U10F.N14 U10F.N15 U10F.N17 U10F.N18 U10F.N19 U10F.P14 U10F.P15 U10F.R4 U10F.R6 U10F.R14 U10F.R18 U10F.R19 U10F.T1 U10F.T3 U10F.T4 U10F.T5 U10F.T6 U10F.T14 U10F.T15 U10F.T16 U10F.T20 U10F.U1 U10F.U2 U10F.U3 U10F.U7 U10F.U15 U10F.U16 U10F.V10 U10F.V13 U10F.V14 U10F.V15 U10F.V19 U10F.V22 U10F.W1 U10F.W2 U10F.W10 U10F.W11 U10F.W12 U10F.W14 U10F.W15 U10F.W16 U10F.Y4 U10F.Y6 U10F.Y11 U10F.Y12 U10F.Y13 U10F.Y14 U10F.Y16 U10F.Y17 U10F.Y21 U10F.Y22 U11C.9 U11C.10 U11C.11 U11C.12 U11C.17 U11C.18 U11C.23 U11C.24 U11C.27 U11C.28 U11C.29 U11C.32 U11C.33 U11C.44 U11C.45 U11C.50 U11C.51 U11C.52 U11C.53 U11C.54 U11C.55 U11C.56 U11C.57 U11C.58 U11C.59 U11C.60 U11D.J1 U11D.J9 U11D.L1 U11D.L9 U11D.M7 U11D.T7 U16P.5

## Polygon pours and split planes (outlines as drawn)
P5.0V on L3 "P5.0V_L03_P020" (solid, remove dead copper, pour order 20): 58.55,40.525 62.225,40.525 63.1,41.4 75.35,41.4 79.575,45.625 83.625,45.625 84.4,46.4 84.4,47.175 83.575,48 78.825,48 74.6,43.775 68.65,43.775 68.1,44.325 65.7,44.325 64.625,43.25 59.675,43.25 58.275,41.85 58.275,40.8
P1.2VTT on L3 "P1.2VTT_L03_P000" (solid, remove dead copper, pour order 0): 53.1,33.4 52.025,34.475 52.025,38.85 51.475,39.4 46.9,39.4 42.475,34.975 42.475,32.025 42.825,31.675 43.625,31.675 44,32.05 55,32.05 55.35,32.4 55.35,33.075 55.025,33.4
GND on L1 "GND_L01_P024" (solid, remove dead copper, pour order 24): 95.9,6 95.9,76.9 60.9,111.9 0.6,111.9 -9.9,101.4 -9.9,12.3 -3.6,6
GND on L1 "GND_L01_P002" (solid, remove dead copper, pour order 2): 18.85,99.4 18.85,90.225 25.225,90.225 25.25,90.2 25.25,96.525 22.35,99.425
GND on L1 "GND_L01_P006" (solid, remove dead copper, pour order 6): 85.025,79.725 85.025,73.75 85,73.725 90.75,73.725 90.775,73.7 90.775,79.75 90.725,79.8
GND on L6 "GND_L06_P004" (solid, remove dead copper, pour order 4): 18.85,99.825 18.85,90.225 24.875,90.225 24.925,90.275 24.925,97.6 22.725,99.8
GND on L6 "GND_L06_P008" (solid, remove dead copper, pour order 8): 85.025,79.925 85.025,73.725 90.675,73.725 90.7,73.7 90.7,79.275 90.25,79.725
GND on L6 "GND_L06_P022" (solid, remove dead copper, pour order 22): -2.8,111.6 87.4,111.6 96.3,102.7 96.3,13.7 88.7,6.1 4.2,6.1 -9.2,19.5 -5.1,23.6 -5.1,111.3
P5.0V on L4 "P5.0V_L04_P018" (solid, remove dead copper, pour order 18): 80.325,68.75 83.325,68.75 84.375,67.7 86.975,67.7 87.975,66.7 87.975,60.05 86.675,58.75 85.25,58.75 79.6,64.4 79.6,68.525
P5.0V on L4 "P5.0V_L04_P014" (solid, remove dead copper, pour order 14): 81.225,61.7 77.4,65.525 77.4,69.05 80.675,69.05 81.925,67.8 81.925,62 81.625,61.7
P5.0V on L4 "P5.0V_L04_P012" (solid, remove dead copper, pour order 12): 78.4,67.475 81.25,64.625 81.25,37.95 72.775,29.475 72.775,22.975 70.125,20.325 49.275,20.325 46.3,17.35 46.3,15.25 47.05,14.5 49.825,14.5 52.7,17.375 74.475,17.375 78.6,21.5 78.6,28.775 86.675,36.85 86.675,58.75 83.3,62.125 83.3,66.625 84.375,67.7 84.375,69.925 80.85,69.925
P5.0V on L4 "P5.0V_L04_P010" (solid, remove dead copper, pour order 10): 84.375,69.925 81.925,67.475 78.4,67.475 73.8,72.075 45,72.075 40.625,67.7 30.35,67.7 28.2,69.85 28.2,71.425 27.35,72.275 17.9,72.275 11.65,66.025 8.7,66.025 7.2,67.525 7.2,74.375 14.775,81.95 83.125,81.95 84.375,80.7
GND on L2 (split plane): 201 vertices, not listed, extent 0.301,0.301 89.699,99.699
P3.3V on L5 (split plane): 201 vertices, not listed, extent 0.301,0.301 89.699,99.699
P1.5V_D on L5 (split plane): 69.048,64.383 69.048,61.9 69.056,61.861 69.078,61.828 69.578,61.328 70.348,60.558 70.348,59.075 70.356,59.036 70.378,59.003 72.428,56.953 72.461,56.931 72.5,56.923 73.473,56.923 73.473,56.292 72.658,55.477 71.875,55.477 71.836,55.469 71.803,55.447 71.278,54.922 71.256,54.889 71.248,54.85 71.248,52.517 65.253,46.522 65.231,46.489 65.223,46.45 65.223,45.4 65.231,45.361 65.253,45.328 66.403,44.178 66.436,44.156 66.475,44.148 66.758,44.148 67.398,43.508 67.398,42.942 66.378,41.922 66.283,41.827 58.975,41.827 58.936,41.819 58.903,41.797 55.708,38.602 51.267,38.602 51.147,38.722 51.114,38.744 51.075,38.752 44.167,38.752 37.672,45.247 37.639,45.269 37.6,45.277 36.95,45.277 36.911,45.269 36.878,45.247 36.608,44.977 35.392,44.977 35.122,45.247 35.089,45.269 35.05,45.277 34.225,45.277 34.186,45.269 34.153,45.247 33.803,44.897 33.781,44.864 33.773,44.825 33.773,44.642 33.566,44.436 32.809,44.436 32.697,44.547 32.664,44.569 32.625,44.577 32.25,44.577 32.211,44.569 32.178,44.547 31.96,44.329 31.534,44.329 30.952,44.911 30.952,46.658 31.272,46.978 31.294,47.011 31.302,47.05 31.302,47.35 31.302,53.083 32.372,54.153 35.017,56.798 36.875,56.798 36.914,56.806 36.947,56.828 41.467,61.348 56.775,61.348 56.814,61.356 56.847,61.378 59.217,63.748 66.675,63.748 66.714,63.756 66.747,63.778 67.617,64.648 68.783,64.648
P1.8V on L5 (split plane): 34.348,42.733 34.348,42.567 34.003,42.222 33.981,42.189 33.973,42.15 33.973,41.6 33.981,41.561 34.003,41.528 34.273,41.258 34.273,40.992 34.053,40.772 34.031,40.739 34.023,40.7 34.023,40.175 34.031,40.136 34.053,40.103 35.028,39.128 35.061,39.106 35.1,39.098 36.9,39.098 36.939,39.106 36.972,39.128 37.167,39.323 37.608,39.323 37.925,39.006 37.925,37.623 37.933,37.584 37.955,37.551 39.748,35.758 39.748,34.575 39.756,34.536 39.778,34.503 40.703,33.578 40.736,33.556 40.775,33.548 41.908,33.548 43.798,31.658 43.798,31.3 43.806,31.261 43.828,31.228 44.873,30.183 44.873,30.059 44.868,30.052 44.861,30.012 44.868,29.973 44.873,29.966 44.873,27.875 44.881,27.836 44.903,27.803 45.248,27.458 45.248,26.525 45.248,22.817 44.108,21.677 43.017,21.677 42.577,22.117 42.577,24.575 42.569,24.614 42.547,24.647 41.477,25.717 41.477,30.025 41.469,30.064 41.447,30.097 41.172,30.372 41.139,30.394 41.1,30.402 40.775,30.402 40.736,30.394 40.703,30.372 40.483,30.152 39.992,30.152 38.697,31.447 38.452,31.692 38.452,32.283 39.272,33.103 39.294,33.136 39.302,33.175 39.302,33.525 39.294,33.564 39.272,33.597 39.222,33.647 38.972,33.897 38.939,33.919 38.9,33.927 38.55,33.927 38.511,33.919 38.478,33.897 38.358,33.777 37.917,33.777 37.177,34.517 37.177,35.737 37.169,35.776 37.147,35.809 36.934,36.022 36.901,36.044 36.862,36.052 35.567,36.052 33.422,38.197 33.389,38.219 33.35,38.227 32.392,38.227 31.502,39.117 31.502,40.758 33.072,42.328 33.912,43.168
P1.0V on L5 (split plane): 44.053,38.578 44.086,38.556 44.125,38.548 51.033,38.548 51.153,38.428 51.186,38.406 51.225,38.398 55.648,38.398 55.648,35.742 55.308,35.402 50.95,35.402 50.911,35.394 50.878,35.372 48.733,33.227 47.65,33.227 47.611,33.219 47.578,33.197 45.828,31.447 45.806,31.414 45.798,31.375 45.798,30.992 45.069,30.263 45.069,30.264 45.047,30.297 44.002,31.342 44.002,31.7 43.994,31.739 43.972,31.772 42.022,33.722 41.989,33.744 41.95,33.752 40.817,33.752 39.952,34.617 39.952,35.8 39.944,35.839 39.922,35.872 38.129,37.665 38.129,39.048 38.121,39.087 38.099,39.12 37.722,39.497 37.689,39.519 37.65,39.527 37.125,39.527 37.086,39.519 37.053,39.497 36.858,39.302 35.142,39.302 34.227,40.217 34.227,40.658 34.447,40.878 34.469,40.911 34.477,40.95 34.477,41.3 34.469,41.339 34.447,41.372 34.177,41.642 34.177,42.108 34.522,42.453 34.544,42.486 34.552,42.525 34.552,42.775 34.544,42.814 34.522,42.847 34.247,43.122 33.739,43.63 33.739,44.32 33.947,44.528 33.969,44.561 33.977,44.6 33.977,44.783 34.267,45.073 35.008,45.073 35.278,44.803 35.311,44.781 35.35,44.773 36.65,44.773 36.689,44.781 36.722,44.803 36.992,45.073 37.558,45.073
VTT on L5 (split plane): 80.248,56.933 80.248,56.267 78.708,54.727 76.525,54.727 76.486,54.719 76.453,54.697 74.078,52.322 74.056,52.289 74.048,52.25 74.048,50.192 69.558,45.702 68.15,45.702 68.111,45.694 68.078,45.672 66.758,44.352 66.517,44.352 65.427,45.442 65.427,46.408 71.422,52.403 71.444,52.436 71.452,52.475 71.452,54.808 71.917,55.273 72.7,55.273 72.739,55.281 72.772,55.303 73.647,56.178 73.669,56.211 73.677,56.25 73.677,57.229 73.946,57.498 79.683,57.498

## Keep-outs
L1:
  rectangle: 0,89.7 12.7,110.15
  rectangle: 79.3,12.75 90,13.75
  region: 0,4.45 15,4.45 ccw(c15,4.5) 15.05,4.5 15.05,12.7 33.3,12.7 33.3,7.95 ccw(c33.35,7.95) 33.35,7.9 41.35,7.9 ccw(c41.35,7.95) 41.4,7.95 ccw(c41.35,7.95) 41.4,7.951 41.4,10.925 cw(c43.175,10.925) 44.95,10.925 ccw(c45,10.925) 45.05,10.925 45.05,13.75 ccw(c45,13.75) 45,13.8 0,13.8 ccw(c0,13.75) -0.05,13.75 -0.05,4.5 ccw(c0,4.5)
L6:
  rectangle: 79.3,12.75 90,13.75
  rectangle: 0,89.7 12.7,110.15
  rectangle: 0,13.75 5.08,89.7
  region: 0,4.45 15,4.45 ccw(c15,4.5) 15.05,4.5 15.05,12.7 33.3,12.7 33.3,7.95 ccw(c33.35,7.95) 33.35,7.9 41.35,7.9 ccw(c41.35,7.95) 41.4,7.95 ccw(c41.35,7.95) 41.4,7.951 41.4,10.925 cw(c43.175,10.925) 44.95,10.925 ccw(c45,10.925) 45.05,10.925 45.05,13.75 ccw(c45,13.75) 45,13.8 0,13.8 ccw(c0,13.75) -0.05,13.75 -0.05,4.5 ccw(c0,4.5)
TopSolder:
  rectangle: 33.35,4.5 41.35,7.95
BottomSolder:
  rectangle: 33.35,4.5 41.35,7.95
KeepOutLayer:
  lines w0.1: 0,4.5 15,4.5 15,12.75 33.35,12.75 33.35,4.5 41.35,4.5 41.35,10.925 cw(c43.175,10.925) 45,10.925 45,0.5 45.5,0 55.7,0 56.2,0.5 56.2,7.45 cw(c57.15,7.45) 58.1,7.45 58.1,0.5 58.6,0 78.8,0 79.3,0.5 79.3,12.75 88.5,12.75 ccw(c88.5,14.25) 90,14.25 90,77.5 ccw(c88.5,77.5) 88.5,79 28.2,79 cw(c28.2,81.656) 26.322,79.778 25.398,80.702 cw(c27.566,82.87) 24.5,82.87 24.5,86.23 24.5,91.63 ccw(c21.434,91.63) 23.602,93.798 18.298,99.102 ccw(c16.13,96.934) 16.13,100 12,100 0,100 0,4.5

## Other copper
L1:
  rectangle net GND: 7.925,71.825 15.125,74.675
  rectangle net P5.0V: 7.86,63.19 12.61,69.51
  pour cut-out: 31.4,8 42.5,8 42.5,3.4 31.4,3.4
L6:
  pour cut-out: 31.4,8 42.5,8 42.5,3.4 31.4,3.4
L2 (plane layer: these items are gaps in the copper):
  rectangle: 33.1,4.5 41.2,8
L5 (plane layer: these items are gaps in the copper):
  rectangle: 33.35,4.5 41.35,8
  lines w0.2: 33.637,44.362 33.637,43.587 34.175,43.05 ; 39.15,33.575 39.2,33.525 ; 44.962,30.012 45.9,30.95 45.9,31.375 47.65,33.125 48.775,33.125 50.95,35.3 55.35,35.3 55.75,35.7 55.75,38.5 ; 45.35,26.525 45.35,27.5 ; 69.65,61.4 69.15,61.9 ; 73.575,57.025 72.5,57.025 70.45,59.075 70.45,60.6 69.15,61.9 ; 74.2,57.6 73.904,57.6 ; 39.2,33.525 39.2,33.175 38.35,32.325 38.35,31.65 38.625,31.375 39.95,30.05 40.525,30.05 40.775,30.3 41.1,30.3 41.375,30.025 41.375,25.675 42.475,24.575 42.475,22.075 42.975,21.575 44.15,21.575 45.35,22.775 45.35,27.5 ; 39.2,33.525 38.9,33.825 38.55,33.825 38.4,33.675 37.875,33.675 37.075,34.475 37.075,35.737 36.862,35.95 35.525,35.95 33.35,38.125 32.35,38.125 31.4,39.075 31.4,40.8 33,42.4 33.912,43.312 34.45,42.775 34.45,42.525 34.075,42.15 34.075,41.6 34.375,41.3 34.375,40.95 34.125,40.7 34.125,40.175 35.1,39.2 36.5,39.2 36.9,39.2 37.125,39.425 37.65,39.425 38.027,39.048 38.027,37.623 39.85,35.8 39.85,34.575 40.775,33.65 41.95,33.65 43.9,31.7 43.9,31.3 44.975,30.225 44.975,27.875 45.35,27.5 ; 55.75,38.5 51.225,38.5 51.075,38.65 48.8,38.65 44.125,38.65 37.6,45.175 36.95,45.175 36.65,44.875 35.35,44.875 35.05,45.175 34.225,45.175 33.875,44.825 33.875,44.6 33.609,44.334 33.359,44.334 32.766,44.334 32.625,44.475 32.25,44.475 32.002,44.227 31.492,44.227 30.85,44.869 30.85,46.7 31.2,47.05 31.2,47.35 31.2,53.125 32.3,54.225 34.975,56.9 36.875,56.9 41.425,61.45 56.775,61.45 59.175,63.85 66.675,63.85 67.575,64.75 68.825,64.75 69.15,64.425 69.15,61.9 ; 55.75,38.5 58.975,41.725 65.5,41.725 66.325,41.725 66.45,41.85 67.5,42.9 67.5,43.55 66.8,44.25 ; 66.8,44.25 66.475,44.25 65.325,45.4 65.325,46.45 71.35,52.475 71.35,54.85 71.875,55.375 72.7,55.375 73.575,56.25 73.575,57.271 73.904,57.6 ; 66.8,44.25 68.15,45.6 69.6,45.6 74.15,50.15 74.15,52.25 76.525,54.625 78.75,54.625 80.35,56.225 80.35,56.975 79.725,57.6 73.904,57.6

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
TopOverlay:
  text "GND" at 20.7,88.9 h1.5
  text "6-18V @ 12W, center +" at 1.7,88.5 h1.5
  text "FUSB" at 70.2,74.9 h1.5 r90
  text "GND" at 86.7,72.6 h1.5
  text "PWR" at 0.2,70.3 h1.5 r270
  text "TX1" at 33.3,66.2 h1.5
  text "F1" at 0.2,65.1 h1.5 r270
  text "OVERLAY" at 47.2,61.9 h1.5
  text "F0" at 0.2,60.6 h1.5 r270
  text "Alphamax LLC / NeTV2 MVP" at 31.1,59 h2
  text "EVT1A - 11/17" at 31.1,57.5 h1.5
  text "RESET" at 84.1,55.2 h1.5
  text "TX0" at 16.4,49.4 h1.5 r270
  text "MUSB" at 85.6,45.3 h1.5
  text "F2" at 0.2,36.6 h1.5 r270
  text "MCU" at 86,33.5 h1.5
  text "3V" at 85,31.4 h1.5
  text "RX" at 84.9,29 h1.5
  text "TDO" at 57.3,28.9 h1.5
  text "TDI" at 60.3,28.9 h1.5
  text "TMS" at 62.6,28.9 h1.5
  text "GND" at 66.9,28.9 h1.5 r90
  text "TCK" at 67.8,28.9 h1.5
  text "TX" at 84.9,26.5 h1.5
  text "RX0" at 16.4,25 h1.5 r270
  text "GND" at 83.9,23.9 h1.5
  text "5V" at 74.4,23.3 h1.5
  text "TX" at 67,22.4 h1.5 r90
  text "RX" at 69.5,22.4 h1.5 r90
  text "GND" at 72.1,21.2 h1.5 r90
  text "GND" at 54.2,21.1 h1.5 r90
  text "RES" at 56.8,21.1 h1.5 r90
  text "SWC" at 59.3,21.1 h1.5 r90
  text "GND" at 61.8,21.1 h1.5 r90
  text "SWD" at 64.4,21.1 h1.5 r90
  text "GND" at 26.9,19 h1.5 r90
  text "GND" at 12.3,15.7 h1.5
  text "HAX" at 25.2,15.7 h1.5
  text "3V" at 38.4,15.7 h1.5
  text "JTAG" at 85.2,15.7 h1.5 r90
  text "MODE" at 86.5,15.6 h1.5 r90
BottomOverlay:
  circle w0.2: c86.625,69.55 r0.811
  rectangle: 1.1,58.3 8.3,74.7
  text "c  2017 Alphamax LLC" at 87.037,69.091 h2
  text "Copyrights: CERN OHL v1.2" at 87.137,67.041 h2
  text "Patents: Apache 2.0" at 87.1,65.1 h2
  text "bunnie@alphamaxmedia.com" at 87.1,63.4 h1.5
  text "3V" at 86.2,31.4 h1.5
  text "TDO" at 58.5,29.8 h1.5 r270
  text "TDI" at 61,29.8 h1.5 r270
  text "TMS" at 63.6,29.8 h1.5 r270
  text "GND" at 66.1,29.8 h1.5 r270
  text "TCK" at 68.6,29.8 h1.5 r270
  text "RX" at 86.3,29 h1.5
  text "TX" at 86.3,26.5 h1.5
  text "GND" at 86.3,23.9 h1.5
  text "RX" at 68.6,21.2 h1.5 r270
  text "GND" at 71.2,21.2 h1.5 r270
  text "5V" at 73.6,21.2 h1.5 r270
  text "5V" at 76.1,21.2 h1.5 r270
  text "GND" at 53.3,21.1 h1.5 r270
  text "RES" at 55.9,21.1 h1.5 r270
  text "SWC" at 58.4,21.1 h1.5 r270
  text "GND" at 60.9,21.1 h1.5 r270
  text "SWD" at 63.5,21.1 h1.5 r270
  text "TX" at 66.1,21.1 h1.5 r270
  text "MODE" at 86.5,19.2 h1.5 r90
  text "JTAG" at 85.2,19 h1.5 r90
TopSolder:
  rectangle: 18.725,90.1 25.125,98.9
  rectangle: 84.925,73.65 90.375,79.625
BottomSolder:
  rectangle: 18.75,90.125 25.05,98.875
  rectangle: 84.925,73.65 90.4,79.65
PCI-SIG Outline:
  lines w0.1: 0,4.5 0,100 12,100 16.13,100 cw(c16.13,96.934) 18.298,99.102 23.602,93.798 cw(c21.434,91.63) 24.5,91.63 24.5,86.23 24.5,82.87 ccw(c27.566,82.87) 25.398,80.702 26.322,79.778 ccw(c28.2,81.656) 28.2,79 88.5,79 cw(c88.5,77.5) 90,77.5 90,14.25 cw(c88.5,14.25) 88.5,12.75 79.3,12.75 79.3,0.5 78.8,0 58.6,0 58.1,0.5 58.1,7.45 ccw(c57.15,7.45) 56.2,7.45 56.2,0.5 55.7,0 45.5,0 45,0.5 45,10.925 ccw(c43.175,10.925) 41.35,10.925 41.35,4.5 33.35,4.5 33.35,12.75 15,12.75 15,4.5 0,4.5
Mechanical2:
  lines w0.1: -3.4,80.9 -0.07,80.9 cw(c-0.07,77.834) 2.098,80.002 4.729,77.371 cw(c4.559,77.2) 4.8,77.2 ; 17,23 17,59 18.7,59 21,59 21,79 ; 23.725,42.75 25.7,40.775 27.15,40.775 29.35,38.575 29.9,38.575 31.425,40.1 33.475,40.1 34.4,39.175 34.4,38.8 ; 26.3,32.1 30.175,35.975 30.55,35.975 30.8,35.725 31.325,35.725 34.4,38.8 ; 30.5,27.775 32.3,29.575 32.725,29.575 32.925,29.375 33.425,29.375 38.55,34.5 38.55,35.025 34.775,38.8 34.4,38.8 ; 42.125,50.625 40.759,49.259 cw(c40.375,49.643) 40.375,49.1 ccw(c40.375,47.591) 39.308,48.658 38.375,47.725 ccw(c40.186,45.914) 37.625,45.914 37.625,45.425 ccw(c38.41,45.425) 37.855,44.87 38.375,44.35 cw(c37.289,43.264) 38.825,43.264 38.825,42.925 ccw(c39.791,42.925) 39.108,42.242 40.3,41.05 ccw(c42.111,42.861) 42.111,40.3 42.15,40.3 cw(c42.15,37.765) 43.942,39.558 44.027,39.473 ccw(c46.195,41.641) 46.195,38.575 53.55,38.575 ; 52.5,21.1 52.5,29.4 ; 52.5,21.5 81.5,21.5 ; 53,63.6 53,88 ; 62.975,47.975 cw(c63.035,47.975) 62.993,48.018 69.625,54.65 ; 63.175,47.25 ccw(c63.175,47.371) 63.26,47.285 70.6,54.625 ; 64.2,46.925 cw(c64.743,46.925) 64.359,47.309 70.675,53.625 ; 81.5,21.2 81.5,26.5 ; 85,79.8 85,88 ; 0,23 85,23 85,79 0,79 0,23
  lines w0.2: 53,88 85,88
  text "32 mm from this back edge to HDMI center" at 55.425,89.475 h0.7
  text "bottom side height restriction = 1mm" at -55.9,79.9 h1.5
  text "+5mm extension for microSD card" at 87.225,54.8 h0.7 r270
  text "Targeting notes:" at 113.3,26.9 h1.5
  text "Long trace runs = 40 ohm (nominal impedance)" at 113,23.2 h1.5
  text "23mm center-center on HDMI connector" at -4.05,21.925 h0.7 r90
  text "*DRAM-DRAM routing = 60 ohm, with DRAM capacitance drops to 40 ohm target" at 113.3,19.7 h1.5
  text "Standardize on 50 ohm @ 0.1mm width" at 113.6,16.3 h1.5
  text "notes: 5 days sch capture, just shy of 3 weeks routing (wall clock time)" at 115,13.9 h1.5
Mechanical3:
  drawing of 4110 lines, arcs and shapes, not listed
  text "Impedance control requirements, +/- 10%" at 108.9,127 h2.5
  text "Layer" at 162.62,123.31 h1.52
  text "Name" at 173.032,123.31 h1.52
  text "Material" at 195.124,123.31 h1.52
  text "Thickness" at 216.962,123.31 h1.52
  text "Constant" at 233.468,123.31 h1.52
  text "Board Layer Stack" at 247.942,123.31 h1.52
  text "SE" at 108.7,123.1 h1.5
  text "DIFF" at 126.4,123.1 h1.5
  text "1" at 162.62,120.262 h1.52
  text "TopOverlay" at 173.032,120.262 h1.52
  text "50 ohm" at 109.1,119.1 h1.5
  text "85 ohm diff" at 123.2,119 h1.5
  text "100 ohm diff" at 142.7,119 h1.5
  text "2" at 162.62,117.214 h1.52
  text "TopSolder" at 173.032,117.214 h1.52
  text "Solder Resist" at 195.124,117.214 h1.52
  text "0.010mm" at 216.962,117.214 h1.52
  text "3.5" at 233.468,117.214 h1.52
  text "0.1/0.1" at 126.3,114.3 h1.5
  text "0.1/0.2" at 145.8,114.3 h1.5
  text "3" at 162.62,114.166 h1.52
  text "L1" at 173.032,114.166 h1.52
  text "Copper" at 195.124,114.166 h1.52
  text "0.045mm" at 216.962,114.166 h1.52
  text "0.1" at 108.8,114.1 h1.5
  text "4" at 162.62,111.118 h1.52
  text "Dielectric1" at 173.032,111.118 h1.52
  text "FR-4" at 195.124,111.118 h1.52
  text "0.080mm" at 216.962,111.118 h1.52
  text "4.3" at 233.468,111.118 h1.52
  text "5" at 162.62,108.07 h1.52
  text "L2" at 173.032,108.07 h1.52
  text "Copper" at 195.124,108.07 h1.52
  text "0.036mm" at 216.962,108.07 h1.52
  text "6" at 162.62,105.022 h1.52
  text "Dielectric4" at 173.032,105.022 h1.52
  text "FR-4" at 195.124,105.022 h1.52
  text "0.100mm" at 216.962,105.022 h1.52
  text "4.3" at 233.468,105.022 h1.52
  text "0.1/0.1" at 126.2,102.2 h1.5
  text "0.1/0.2" at 145.7,102.2 h1.5
  text "0.1" at 108.7,102.1 h1.5
  text "7" at 162.62,101.974 h1.52
  text "L3" at 173.032,101.974 h1.52
  text "Copper" at 195.124,101.974 h1.52
  text "0.036mm" at 216.962,101.974 h1.52
  text "8" at 162.62,98.926 h1.52
  text "Dielectric2" at 173.032,98.926 h1.52
  text "FR-4" at 195.124,98.926 h1.52
  text "0.950mm" at 216.962,98.926 h1.52
  text "4.3" at 233.468,98.926 h1.52
  text "0.1/0.1" at 126,96.4 h1.5
  text "0.1/0.2" at 145.5,96.4 h1.5
  text "0.1" at 108.6,95.9 h1.5
  text "9" at 162.62,95.878 h1.52
  text "L4" at 173.032,95.878 h1.52
  text "Copper" at 195.124,95.878 h1.52
  text "0.036mm" at 216.962,95.878 h1.52
  text "10" at 162.62,92.83 h1.52
  text "Dielectric3" at 173.032,92.83 h1.52
  text "FR-4" at 195.124,92.83 h1.52
  text "0.100mm" at 216.962,92.83 h1.52
  text "4.3" at 233.468,92.83 h1.52
  text "11" at 162.62,89.782 h1.52
  text "L5" at 173.032,89.782 h1.52
  text "Copper" at 195.124,89.782 h1.52
  text "0.036mm" at 216.962,89.782 h1.52
  text "0.1/0.2 pairs = 100 ohm differential" at 43.3,88.4 h1.5 r90
  text "0.1/0.2 pairs = 100 ohm differential" at 51.7,88.2 h1.5 r90
  text "12" at 162.62,86.734 h1.52
  text "Dielectric5" at 173.032,86.734 h1.52
  text "FR-4" at 195.124,86.734 h1.52
  text "0.080mm" at 216.962,86.734 h1.52
  text "4.3" at 233.468,86.734 h1.52
  text "All 0.1mm traces all layers = 50 ohm" at 69.8,86.6 h1.5 r90
  text "13" at 162.62,83.686 h1.52
  text "L6" at 173.032,83.686 h1.52
  text "Copper" at 195.124,83.686 h1.52
  text "0.045mm" at 216.962,83.686 h1.52
  text "0.1/0.1" at 125.7,83.5 h1.5
  text "0.1/0.2" at 145.2,83.5 h1.5
  text "0.1" at 108.6,83.3 h1.5
  text "14" at 162.62,80.638 h1.52
  text "BottomSolder" at 173.032,80.638 h1.52
  text "Solder Resist" at 195.124,80.638 h1.52
  text "0.010mm" at 216.962,80.638 h1.52
  text "3.5" at 233.468,80.638 h1.52
  text "15" at 162.62,77.59 h1.52
  text "BottomOverlay" at 173.032,77.59 h1.52
  text "soldermask: green" at 114.7,71.7 h2
  text "silkscreen: white" at 114.5,67.8 h2
  text "Finish: immersion gold, except on card-edge fingers 15u\" gold" at 114.6,63.7 h2
  text "0.1/0.1 pairs = 85 ohm differential" at 86.1,7.7 h1.5
  text "0.1/0.1 pairs = 85 ohm differential" at 83.8,3.4 h1.5
  text "bevel specification on card edge" at 32.1,-5.8 h2
  text "Edge connector bevel instructions and target board width" at 19.4,-28.3 h0.7
  text "15u\" gold on fingers" at 19.5,-31.1 h1
PCI-SIG Notes:
  text "- Nominal values used, dimensions in mm" at 104.4,63.184 h1.52
  text "- The mounting holes and keep-out areas around them are only required when the I/O bracket is mounted on the card directly" at 104.4,61.406 h1.52
  text "- Component height rule and clearance rule derived from PCI_Express_CEM_r2.0.pdf, Page 84." at 104.4,59.628 h1.52
  text "- Stackup is not specified in PCI_Express_CEM_r2.0.pdf, nor implemented in this template." at 104.4,57.85 h1.52
DrillDrawing:
  text ".LEGEND" at 225.25,59.352 h1
  text "Drilling Details." at 225.25,57.523 h1

## Dimensions
0,0 to 0,100 on PCI-SIG Dimensions
0,4.5 to 0,100 on PCI-SIG Dimensions
0,111.15 to 90,111.15 on PCI-SIG Dimensions
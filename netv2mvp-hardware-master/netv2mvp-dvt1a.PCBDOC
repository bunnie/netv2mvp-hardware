# Altium PCB netv2mvp-dvt1a.PCBDOC (part 2 of 6)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 90 x 100 mm, 6 copper layers (L1, L2, L3, L4, L5, L6), stack 1.542 mm thick; 329 components, 277 nets, 2092 pads, 848 vias.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad) (continued)
COILCRAFT_MSS1038 [mm] "Coilcraft shielded power inductor"
  rect 3.56x1.78 smd mask+0.075: 1(0,0) 2(0,9.4)
  silkscreen extent -5.1,-0.75 5.1,10.25, body extent -5.1,-0.75 5.1,10.25, height 3.8
CUI_PJ_002AH_SMT [mm] "SMT 2.1mmx5.5mm ID (P-5) connector"
  round 1.6 hole 1.6 unplated: 0(-4.5,0)
  round 1.8 hole 1.8 unplated: 0(0,0)
  rect 2.8x2.4 smd: 1(-4.5,5.7) 1(1.6,5.7) 2(-4.5,-5.7) 3(1.6,-5.7)
  silkscreen extent -9.6,-4.4 5.2,4.4, body extent -9.5,-6.3 5.3,6.3, height 11.19
FGG484 [mm] "BGA, 484-Balls, Body 23x23mm, Pitch 1mm"
  round 0.5 smd: A1(-10.5,10.5) A2(-9.5,10.5) A3(-8.5,10.5) A4(-7.5,10.5) A5(-6.5,10.5) A6(-5.5,10.5) A7(-4.5,10.5) A8(-3.5,10.5) A9(-2.5,10.5) A10(-1.5,10.5) A11(-0.5,10.5) A12(0.5,10.5) A13(1.5,10.5) A14(2.5,10.5) A15(3.5,10.5) A16(4.5,10.5) A17(5.5,10.5) A18(6.5,10.5) A19(7.5,10.5) A20(8.5,10.5) A21(9.5,10.5) A22(10.5,10.5) AA1(-10.5,-9.5) AA2(-9.5,-9.5) AA3(-8.5,-9.5) AA4(-7.5,-9.5) AA5(-6.5,-9.5) AA6(-5.5,-9.5) AA7(-4.5,-9.5) AA8(-3.5,-9.5) AA9(-2.5,-9.5) AA10(-1.5,-9.5) AA11(-0.5,-9.5) AA12(0.5,-9.5) AA13(1.5,-9.5) AA14(2.5,-9.5) AA15(3.5,-9.5) AA16(4.5,-9.5) AA17(5.5,-9.5) AA18(6.5,-9.5) AA19(7.5,-9.5) AA20(8.5,-9.5) AA21(9.5,-9.5) AA22(10.5,-9.5) AB1(-10.5,-10.5) AB2(-9.5,-10.5) AB3(-8.5,-10.5) AB4(-7.5,-10.5) AB5(-6.5,-10.5) AB6(-5.5,-10.5) AB7(-4.5,-10.5) AB8(-3.5,-10.5) AB9(-2.5,-10.5) AB10(-1.5,-10.5) AB11(-0.5,-10.5) AB12(0.5,-10.5) AB13(1.5,-10.5) AB14(2.5,-10.5) AB15(3.5,-10.5) AB16(4.5,-10.5) AB17(5.5,-10.5) AB18(6.5,-10.5) AB19(7.5,-10.5) AB20(8.5,-10.5) AB21(9.5,-10.5) AB22(10.5,-10.5) B1(-10.5,9.5) B2(-9.5,9.5) B3(-8.5,9.5) B4(-7.5,9.5) B5(-6.5,9.5) B6(-5.5,9.5) B7(-4.5,9.5) B8(-3.5,9.5) B9(-2.5,9.5) B10(-1.5,9.5) B11(-0.5,9.5) B12(0.5,9.5) B13(1.5,9.5) B14(2.5,9.5) B15(3.5,9.5) B16(4.5,9.5) B17(5.5,9.5) B18(6.5,9.5) B19(7.5,9.5) B20(8.5,9.5) B21(9.5,9.5) B22(10.5,9.5) C1(-10.5,8.5) C2(-9.5,8.5) C3(-8.5,8.5) C4(-7.5,8.5) C5(-6.5,8.5) C6(-5.5,8.5) C7(-4.5,8.5) C8(-3.5,8.5) C9(-2.5,8.5) C10(-1.5,8.5) C11(-0.5,8.5) C12(0.5,8.5) C13(1.5,8.5) C14(2.5,8.5) C15(3.5,8.5) C16(4.5,8.5) C17(5.5,8.5) C18(6.5,8.5) C19(7.5,8.5) C20(8.5,8.5) C21(9.5,8.5) C22(10.5,8.5) D1(-10.5,7.5) D2(-9.5,7.5) D3(-8.5,7.5) D4(-7.5,7.5) D5(-6.5,7.5) D6(-5.5,7.5) D7(-4.5,7.5) D8(-3.5,7.5) D9(-2.5,7.5) D10(-1.5,7.5) D11(-0.5,7.5) D12(0.5,7.5) D13(1.5,7.5) D14(2.5,7.5) D15(3.5,7.5) D16(4.5,7.5) D17(5.5,7.5) D18(6.5,7.5) D19(7.5,7.5) D20(8.5,7.5) D21(9.5,7.5) D22(10.5,7.5) E1(-10.5,6.5) E2(-9.5,6.5) E3(-8.5,6.5) E4(-7.5,6.5) E5(-6.5,6.5) E6(-5.5,6.5) E7(-4.5,6.5) E8(-3.5,6.5) E9(-2.5,6.5) E10(-1.5,6.5) E11(-0.5,6.5) E12(0.5,6.5) E13(1.5,6.5) E14(2.5,6.5) E15(3.5,6.5) E16(4.5,6.5) E17(5.5,6.5) E18(6.5,6.5) E19(7.5,6.5) E20(8.5,6.5) E21(9.5,6.5) E22(10.5,6.5) F1(-10.5,5.5) F2(-9.5,5.5) F3(-8.5,5.5) F4(-7.5,5.5) F5(-6.5,5.5) F6(-5.5,5.5) F7(-4.5,5.5) F8(-3.5,5.5) F9(-2.5,5.5) F10(-1.5,5.5) F11(-0.5,5.5) F12(0.5,5.5) F13(1.5,5.5) F14(2.5,5.5) F15(3.5,5.5) F16(4.5,5.5) F17(5.5,5.5) F18(6.5,5.5) F19(7.5,5.5) F20(8.5,5.5) F21(9.5,5.5) F22(10.5,5.5) G1(-10.5,4.5) G2(-9.5,4.5) G3(-8.5,4.5) G4(-7.5,4.5) G5(-6.5,4.5) G6(-5.5,4.5) G7(-4.5,4.5) G8(-3.5,4.5) G9(-2.5,4.5) G10(-1.5,4.5) G11(-0.5,4.5) G12(0.5,4.5) G13(1.5,4.5) G14(2.5,4.5) G15(3.5,4.5) G16(4.5,4.5) G17(5.5,4.5) G18(6.5,4.5) G19(7.5,4.5) G20(8.5,4.5) G21(9.5,4.5) G22(10.5,4.5) H1(-10.5,3.5) H2(-9.5,3.5) H3(-8.5,3.5) H4(-7.5,3.5) H5(-6.5,3.5) H6(-5.5,3.5) H7(-4.5,3.5) H8(-3.5,3.5) H9(-2.5,3.5) H10(-1.5,3.5) H11(-0.5,3.5) H12(0.5,3.5) H13(1.5,3.5) H14(2.5,3.5) H15(3.5,3.5) H16(4.5,3.5) H17(5.5,3.5) H18(6.5,3.5) H19(7.5,3.5) H20(8.5,3.5) H21(9.5,3.5) H22(10.5,3.5) J1(-10.5,2.5) J2(-9.5,2.5) J3(-8.5,2.5) J4(-7.5,2.5) J5(-6.5,2.5) J6(-5.5,2.5) J7(-4.5,2.5) J8(-3.5,2.5) J9(-2.5,2.5) J10(-1.5,2.5) J11(-0.5,2.5) J12(0.5,2.5) J13(1.5,2.5) J14(2.5,2.5) J15(3.5,2.5) J16(4.5,2.5) J17(5.5,2.5) J18(6.5,2.5) J19(7.5,2.5) J20(8.5,2.5) J21(9.5,2.5) J22(10.5,2.5) K1(-10.5,1.5) K2(-9.5,1.5) K3(-8.5,1.5) K4(-7.5,1.5) K5(-6.5,1.5) K6(-5.5,1.5) K7(-4.5,1.5) K8(-3.5,1.5) K9(-2.5,1.5) K10(-1.5,1.5) K11(-0.5,1.5) K12(0.5,1.5) K13(1.5,1.5) K14(2.5,1.5) K15(3.5,1.5) K16(4.5,1.5) K17(5.5,1.5) K18(6.5,1.5) K19(7.5,1.5) K20(8.5,1.5) K21(9.5,1.5) K22(10.5,1.5) L1(-10.5,0.5) L2(-9.5,0.5) L3(-8.5,0.5) L4(-7.5,0.5) L5(-6.5,0.5) L6(-5.5,0.5) L7(-4.5,0.5) L8(-3.5,0.5) L9(-2.5,0.5) L10(-1.5,0.5) L11(-0.5,0.5) L12(0.5,0.5) L13(1.5,0.5) L14(2.5,0.5) L15(3.5,0.5) L16(4.5,0.5) L17(5.5,0.5) L18(6.5,0.5) L19(7.5,0.5) L20(8.5,0.5) L21(9.5,0.5) L22(10.5,0.5) M1(-10.5,-0.5) M2(-9.5,-0.5) M3(-8.5,-0.5) M4(-7.5,-0.5) M5(-6.5,-0.5) M6(-5.5,-0.5) M7(-4.5,-0.5) M8(-3.5,-0.5) M9(-2.5,-0.5) M10(-1.5,-0.5) M11(-0.5,-0.5) M12(0.5,-0.5) M13(1.5,-0.5) M14(2.5,-0.5) M15(3.5,-0.5) M16(4.5,-0.5) M17(5.5,-0.5) M18(6.5,-0.5) M19(7.5,-0.5) M20(8.5,-0.5) M21(9.5,-0.5) M22(10.5,-0.5) N1(-10.5,-1.5) N2(-9.5,-1.5) N3(-8.5,-1.5) N4(-7.5,-1.5) N5(-6.5,-1.5) N6(-5.5,-1.5) N7(-4.5,-1.5) N8(-3.5,-1.5) N9(-2.5,-1.5) N10(-1.5,-1.5) N11(-0.5,-1.5) N12(0.5,-1.5) N13(1.5,-1.5) N14(2.5,-1.5) N15(3.5,-1.5) N16(4.5,-1.5) N17(5.5,-1.5) N18(6.5,-1.5) N19(7.5,-1.5) N20(8.5,-1.5) N21(9.5,-1.5) N22(10.5,-1.5) P1(-10.5,-2.5) P2(-9.5,-2.5) P3(-8.5,-2.5) P4(-7.5,-2.5) P5(-6.5,-2.5) P6(-5.5,-2.5) P7(-4.5,-2.5) P8(-3.5,-2.5) P9(-2.5,-2.5) P10(-1.5,-2.5) P11(-0.5,-2.5) P12(0.5,-2.5) P13(1.5,-2.5) P14(2.5,-2.5) P15(3.5,-2.5) P16(4.5,-2.5) P17(5.5,-2.5) P18(6.5,-2.5) P19(7.5,-2.5) P20(8.5,-2.5) P21(9.5,-2.5) P22(10.5,-2.5) R1(-10.5,-3.5) R2(-9.5,-3.5) R3(-8.5,-3.5) R4(-7.5,-3.5) R5(-6.5,-3.5) R6(-5.5,-3.5) R7(-4.5,-3.5) R8(-3.5,-3.5) R9(-2.5,-3.5) R10(-1.5,-3.5) R11(-0.5,-3.5) R12(0.5,-3.5) R13(1.5,-3.5) R14(2.5,-3.5) R15(3.5,-3.5) R16(4.5,-3.5) R17(5.5,-3.5) R18(6.5,-3.5) R19(7.5,-3.5) R20(8.5,-3.5) R21(9.5,-3.5) R22(10.5,-3.5) T1(-10.5,-4.5) T2(-9.5,-4.5) T3(-8.5,-4.5) T4(-7.5,-4.5) T5(-6.5,-4.5) T6(-5.5,-4.5) T7(-4.5,-4.5) T8(-3.5,-4.5) T9(-2.5,-4.5) T10(-1.5,-4.5) T11(-0.5,-4.5) T12(0.5,-4.5) T13(1.5,-4.5) T14(2.5,-4.5) T15(3.5,-4.5) T16(4.5,-4.5) T17(5.5,-4.5) T18(6.5,-4.5) T19(7.5,-4.5) T20(8.5,-4.5) T21(9.5,-4.5) T22(10.5,-4.5) U1(-10.5,-5.5) U2(-9.5,-5.5) U3(-8.5,-5.5) U4(-7.5,-5.5) U5(-6.5,-5.5) U6(-5.5,-5.5) U7(-4.5,-5.5) U8(-3.5,-5.5) U9(-2.5,-5.5) U10(-1.5,-5.5) U11(-0.5,-5.5) U12(0.5,-5.5) U13(1.5,-5.5) U14(2.5,-5.5) U15(3.5,-5.5) U16(4.5,-5.5) U17(5.5,-5.5) U18(6.5,-5.5) U19(7.5,-5.5) U20(8.5,-5.5) U21(9.5,-5.5) U22(10.5,-5.5) V1(-10.5,-6.5) V2(-9.5,-6.5) V3(-8.5,-6.5) V4(-7.5,-6.5) V5(-6.5,-6.5) V6(-5.5,-6.5) V7(-4.5,-6.5) V8(-3.5,-6.5) V9(-2.5,-6.5) V10(-1.5,-6.5) V11(-0.5,-6.5) V12(0.5,-6.5) V13(1.5,-6.5) V14(2.5,-6.5) V15(3.5,-6.5) V16(4.5,-6.5) V17(5.5,-6.5) V18(6.5,-6.5) V19(7.5,-6.5) V20(8.5,-6.5) V21(9.5,-6.5) V22(10.5,-6.5) W1(-10.5,-7.5) W2(-9.5,-7.5) W3(-8.5,-7.5) W4(-7.5,-7.5) W5(-6.5,-7.5) W6(-5.5,-7.5) W7(-4.5,-7.5) W8(-3.5,-7.5) W9(-2.5,-7.5) W10(-1.5,-7.5) W11(-0.5,-7.5) W12(0.5,-7.5) W13(1.5,-7.5) W14(2.5,-7.5) W15(3.5,-7.5) W16(4.5,-7.5) W17(5.5,-7.5) W18(6.5,-7.5) W19(7.5,-7.5) W20(8.5,-7.5) W21(9.5,-7.5) W22(10.5,-7.5) Y1(-10.5,-8.5) Y2(-9.5,-8.5) Y3(-8.5,-8.5) Y4(-7.5,-8.5) Y5(-6.5,-8.5) Y6(-5.5,-8.5) Y7(-4.5,-8.5) Y8(-3.5,-8.5) Y9(-2.5,-8.5) Y10(-1.5,-8.5) Y11(-0.5,-8.5) Y12(0.5,-8.5) Y13(1.5,-8.5) Y14(2.5,-8.5) Y15(3.5,-8.5) Y16(4.5,-8.5) Y17(5.5,-8.5) Y18(6.5,-8.5) Y19(7.5,-8.5) Y20(8.5,-8.5) Y21(9.5,-8.5) Y22(10.5,-8.5)
  silkscreen extent -12.27,-11.5 11.5,11.5, body extent -11.5,-11.5 11.5,11.5, height 2.6
HDR1X2 [mm] "Connector; Header; 2 Position"
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(2.54,0)
  silkscreen extent -1.27,-1.27 3.81,1.27
HDR1X4 [mm] "Connector; Header; 4 Position"
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(2.54,0) 3(5.08,0) 4(7.62,0)
  silkscreen extent -1.27,-1.27 8.89,1.27
HDR2X10 [mm] "Connector; Header; 10x2 Position"
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54)
  silkscreen extent -1.27,-1.27 24.13,3.81
HDR2X11 [mm] "Connector; Header; 11x2 Position"
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54) 21(25.4,0) 22(25.4,2.54)
  silkscreen extent -1.27,-1.27 26.67,3.81
MICT-HA-96 [mm] "BGA, 96-Balls, Body 14x9mm, Pitch 0.8mm"
  round 0.4 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
  silkscreen extent -5.27,-7 4.5,7, body extent -4.5,-7 4.5,7, height 0.1
MOLEX_47151-0001 [mm] "Molex HDMI right angle header assembly"
  oval 1.5x3.3 hole 0.9 slot 2.7 at 90 deg mask+0.07: 0(-7.25,0) 0(7.25,0)
  oval 1.5x2.3 hole 0.9 slot 1.7 at 90 deg mask+0.07: 0(-7.25,-5.96) 0(7.25,-5.96)
  rect 0.3x2.6 smd mask+0.07: 1(4.5,0.76) 2(4,0.76) 3(3.5,0.76) 4(3,0.76) 5(2.5,0.76) 6(2,0.76) 7(1.5,0.76) 8(1,0.76) 9(0.5,0.76) 10(0,0.76) 11(-0.5,0.76) 12(-1,0.76) 13(-1.5,0.76) 14(-2,0.76) 15(-2.5,0.76) 16(-3,0.76) 17(-3.5,0.76) 18(-4,0.76) 19(-4.5,0.76)
  silkscreen extent -8.4,-10.55 8.4,2.76, body extent -7.5,-10.55 7.5,1.6, height 6.18
MOLEX_0467651301 [mm] "HDMI-D connector, through-hole shell pins"
  oval 1.5x2.55 hole 0.65 slot 1.7 at 90 deg mask+0.07: 0(-3.1,5.06) 0(-3.1,1.7) 0(3.1,5.06) 0(3.1,1.7)
  rect 0.23x0.85 smd mask+0.03: 1(1.8,6.475) 3(1.4,6.475) 5(1,6.475) 7(0.6,6.475) 9(0.2,6.475) 11(-0.2,6.475) 13(-0.6,6.475) 15(-1,6.475) 17(-1.4,6.475) 19(-1.8,6.475)
  rect 0.23x1 smd mask+0.03: 2(1.6,5.25) 4(1.2,5.25) 6(0.8,5.25) 8(0.4,5.25) 10(0,5.25) 12(-0.4,5.25) 14(-0.8,5.25) 16(-1.2,5.25) 18(-1.6,5.25)
  silkscreen extent -3.88,-0.7 3.88,0, body extent -3.25,-0.7 3.25,6.8, height 2.95
PANASONIC_EXB24V [mm] "2x0402 resistor network"
  rect 0.38x0.5 smd mask+0.076: 1(0,0) 2(0.65,0) 3(0.65,1) 4(0,1)
  silkscreen extent -0.15,-0.53 0.05,-0.53, body extent -0.27,-0.08 0.93,1.07, height 0.35
PANASONIC_EXB28V [mm] "4x0402 resistor network"
  rect 0.525x0.5 smd mask+0.076: 1(-0.138,0) 4(1.638,0) 5(1.638,0.9) 8(-0.138,0.9)
  rect 0.25x0.5 smd mask+0.076: 2(0.5,0) 3(1,0) 6(1,0.9) 7(0.5,0.9)
  silkscreen extent -0.47,-0.53 -0.27,-0.52, body extent -0.4,-0.07 1.9,0.98, height 0.35
PCIeX4-GF-2D-1000-1K-O64 [mm] "Golden finger, PCIeX4, Dual, Opposite, Pitch 1mm, 64-Position"
  rect 0.7x3.2 smd far side: A1(-9.5,0.5)
  rect 0.7x4.2 smd far side: A2(-8.5,0) A3(-7.5,0) A4(-6.5,0) A5(-5.5,0) A6(-4.5,0) A7(-3.5,0) A8(-2.5,0) A9(-1.5,0) A10(-0.5,0) A11(0.5,0) A12(3.5,0) A13(4.5,0) A14(5.5,0) A15(6.5,0) A16(7.5,0) A17(8.5,0) A18(9.5,0) A19(10.5,0) A20(11.5,0) A21(12.5,0) A22(13.5,0) A23(14.5,0) A24(15.5,0) A25(16.5,0) A26(17.5,0) A27(18.5,0) A28(19.5,0) A29(20.5,0) A30(21.5,0) A31(22.5,0) A32(23.5,0)
  rect 0.7x4.2 smd: B1(-9.5,0) B2(-8.5,0) B3(-7.5,0) B4(-6.5,0) B5(-5.5,0) B6(-4.5,0) B7(-3.5,0) B8(-2.5,0) B9(-1.5,0) B10(-0.5,0) B11(0.5,0) B12(3.5,0) B13(4.5,0) B14(5.5,0) B15(6.5,0) B16(7.5,0) B18(9.5,0) B19(10.5,0) B20(11.5,0) B21(12.5,0) B22(13.5,0) B23(14.5,0) B24(15.5,0) B25(16.5,0) B26(17.5,0) B27(18.5,0) B28(19.5,0) B29(20.5,0) B30(21.5,0) B32(23.5,0)
  rect 0.7x3.2 smd: B17(8.5,0.5) B31(22.5,0.5)
RESC1005N [mm] "Chip Resistor, Body 1.1x0.5mm, IPC Medium Density"
  rect 0.8x0.7 smd: 1(-0.6,0) 2(0.6,0)
  body extent -0.55,-0.3 0.55,0.3, height 0.4
RESC1608N [mm] "Chip Resistor, Body 1.6x0.8mm, IPC Medium Density"
  rect 0.9x1 smd: 1(-0.85,0) 2(0.85,0)
  silkscreen extent -0.2,-0.4 0.2,0.4, body extent -0.85,-0.48 0.85,0.48, height 0.6
RESC2012N [mm] "Chip Resistor, Body 2.0x1.3mm, IPC Medium Density"
  rect 1.2x1.4 smd: 1(-0.9,0) 2(0.9,0)
  silkscreen extent 0,-0.6 0,0.6, body extent -1.07,-0.7 1.07,0.7, height 0.65
SEMTECH_SLP2510P8 [mm] "Semtech array ESD package"
  rect 0.2x0.675 smd mask+0.038: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.438) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.4x1.55 smd mask+0.038: 3(0,0)
  silkscreen extent -1.7,-1.5 1.4,0.6, body extent -1.3,-0.6 1.3,0.6, height 0.65
SOD-323 [mm] "SOD-323/SC-76; 2 Leads; Body 1.7 x 1.3 mm, (LxW)"
  rect 1.45x0.55 smd: 1(1.175,0) 2(-1.175,0)
  silkscreen extent -0.95,-0.75 0.95,0.75
SOD-523 [mm] "Molded Diode, 2-Leads, Body 1.2x0.8mm, IPC Medium Density"
  rect 0.6x0.4 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -1.3,-0.45 0.15,0.45, body extent -0.65,-0.45 0.65,0.45, height 0.7
SOIC127P790X216-8N [mm] "SOIC, 8-Leads, Body 5.23x5.28mm, Pitch 1.27mm, IPC Medium Density"
  oval 1.7x0.65 smd: 1(-3.55,1.905) 2(-3.55,0.635) 3(-3.55,-0.635) 4(-3.55,-1.905) 5(3.55,-1.905) 6(3.55,-0.635) 7(3.55,0.635) 8(3.55,1.905)
  silkscreen extent -3.67,-2.65 2.3,2.91, body extent -2.7,-2.65 2.7,2.65, height 2.16
SOT23-3N [mm] "SOT23, 3-Leads, Body 2.9x1.3mm, Pitch 0.95mm, Lead Span 2.5mm, IPC Medium Density"
  rect 1.5x0.6 smd: 1(-0.95,0.95) 2(-0.95,-0.95) 3(0.95,0)
  silkscreen extent -1.07,-1.5 0.7,1.92, body extent -0.7,-1.5 0.7,1.5, height 1.1
SOT26A-6N [mm] "SOT23, 6-Leads, Body 2.9x1.7mm, Pitch 0.95mm, Lead Span 2.8mm, IPC Medium Density"
  rect 1.1x0.65 smd: 1(-1.2,0.95) 2(-1.2,0) 3(-1.2,-0.95) 4(1.2,-0.95) 5(1.2,0) 6(1.2,0.95)
  silkscreen extent -1.32,-1.55 0.25,1.95, body extent -0.9,-1.55 0.9,1.55, height 1.45
SWITCH_TS-1187A [mm] "TS-1187A tact switch, Chi Fung Electronics"
  rect 1.5x1.5 smd mask+0.07: 1(0,0) 2(0,-5.5) 3(3.7,0) 4(3.7,-5.5)
  silkscreen extent -0.7,-5.3 4.4,-0.2, body extent -0.7,-5.3 4.4,-0.2, height 1.6
TI-DSQ-R-PWSON-N10 [mm] "SON, 10-Leads, Body 2.00x2.00mm, Pitch 0.40mm, Thermal Pad 1.50x0.79mm, IPC Medium Density"
  rect 0.75x0.2 smd mask+0.07: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(1.94,-1.6) 7(1.94,-1.2) 8(1.94,-0.8) 9(1.94,-0.4) 10(1.94,0)
  rect 0.79x1.5 smd paste-0.4 mask+0.07: 11(0.97,-0.8)
  silkscreen extent -0.64,0.26 -0.54,0.36, body extent -0.08,-1.85 2.02,0.25, height 0.8
TI_YKE004 [mm] "DSBGA with SMD pads, 4-Leads, Body 0.65x0.65mmx0.45mm, Pitch 0.35mm"
  round 0.25 smd mask-0.04: A1(-0.175,0.175) A2(0.175,0.175) B1(-0.175,-0.175) B2(0.175,-0.175)
  silkscreen extent -0.48,0.38 -0.38,0.48, body extent -0.33,-0.32 0.32,0.33, height 0.45
TP_2MM_SQ [mm] "2mm x 2mm square test pad"
  rrect50% 2x2 smd: 1(0,0)
TSOP65P640-14AN [mm] "TSOP, 14-Leads, Body 5x4.4mm, Pitch 0.65mm, IPC Medium Density"
  oval 1.7x0.35 smd: 1(-2.85,1.95) 2(-2.85,1.3) 3(-2.85,0.65) 4(-2.85,0) 5(-2.85,-0.65) 6(-2.85,-1.3) 7(-2.85,-1.95) 8(2.85,-1.95) 9(2.85,-1.3) 10(2.85,-0.65) 11(2.85,0) 12(2.85,0.65) 13(2.85,1.3) 14(2.85,1.95)
  silkscreen extent -2.97,-2.55 1.6,2.8, body extent -2.25,-2.55 2.25,2.55, height 1.2
TSQFP50P1200X1200-64N [mm] "Thin QFP, 64-Leads, Body 10x10mm, Pitch 0.5mm, IPC Medium Density"
  oval 1.8x0.3 smd: 1(-5.55,3.75) 2(-5.55,3.25) 3(-5.55,2.75) 4(-5.55,2.25) 5(-5.55,1.75) 6(-5.55,1.25) 7(-5.55,0.75) 8(-5.55,0.25) 9(-5.55,-0.25) 10(-5.55,-0.75) 11(-5.55,-1.25) 12(-5.55,-1.75) 13(-5.55,-2.25) 14(-5.55,-2.75) 15(-5.55,-3.25) 16(-5.55,-3.75) 33(5.55,-3.75) 34(5.55,-3.25) 35(5.55,-2.75) 36(5.55,-2.25) 37(5.55,-1.75) 38(5.55,-1.25) 39(5.55,-0.75) 40(5.55,-0.25) 41(5.55,0.25) 42(5.55,0.75) 43(5.55,1.25) 44(5.55,1.75) 45(5.55,2.25) 46(5.55,2.75) 47(5.55,3.25) 48(5.55,3.75)
  oval 0.3x1.8 smd: 17(-3.75,-5.55) 18(-3.25,-5.55) 19(-2.75,-5.55) 20(-2.25,-5.55) 21(-1.75,-5.55) 22(-1.25,-5.55) 23(-0.75,-5.55) 24(-0.25,-5.55) 25(0.25,-5.55) 26(0.75,-5.55) 27(1.25,-5.55) 28(1.75,-5.55) 29(2.25,-5.55) 30(2.75,-5.55) 31(3.25,-5.55) 32(3.75,-5.55) 49(3.75,5.55) 50(3.25,5.55) 51(2.75,5.55) 52(2.25,5.55) 53(1.75,5.55) 54(1.25,5.55) 55(0.75,5.55) 56(0.25,5.55) 57(-0.25,5.55) 58(-0.75,5.55) 59(-1.25,5.55) 60(-1.75,5.55) 61(-2.25,5.55) 62(-2.75,5.55) 63(-3.25,5.55) 64(-3.75,5.55)
  silkscreen extent -5.68,-4.25 4.25,4.57, body extent -5,-5 5,5, height 1.6
USB_MICRO_B_SMT [mm] "Micro B SMT footprint (based on USB-IF recommended pattern)"
  rect 1.825x0.7 smd mask+0.07: 0(-3,1.7) 0(3,1.7)
  rect 2x1.4 smd mask+0.07: 0(-2.9,3.03) 0(2.9,3.03)
  oval 1.3x1.6 hole 0.66 slot 1.2 at 90 deg mask+0.07: 0(-2.725,0) 0(2.725,0)
  rrect50% 1.3x3.15 smd mask+0.07: 0(-2.725,0.475) 0(2.725,0.475)
  oval 1x1.4 hole 0.66 slot 1.05 at 90 deg mask+0.07: 0(-2.425,3.03) 0(2.425,3.03)
  rect 1.425x2.5 smd mask+0.07: 0(-0.975,-0.25) 0(0.975,-0.25)
  rect 0.4x1.75 smd mask+0.07: 1(-1.3,2.825) 2(-0.65,2.825) 3(0,2.825) 4(0.65,2.825) 5(1.3,2.825)
  silkscreen extent -3.4,-1.7 3.3,-1.7, body extent -4.02,-2.75 4.02,3.28, height 2.85

## Part data
C10C C10H C11D C11F C12C C12D C12F C12H C14D C15F C16C C16D C16F C17D C18C C18D C19C C19D C20C C20F C21C C21F C22F C23C C23F C24F C25F C27D C27F C29D C31D C32D C33D C34D C35D C36D C36F C37F C37P C38D C39D C40D C40F C41D C42D C43D C50D C87F C88F C89F: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL03A104KQ3NNNC
C10D C10F C15D C17F C20D C21D C26D C28D C28F C29F C30D C37D C38F C44D C46F C47F C48F C56F C57F C58F C63F C64F C65F C70F C71F C72F C77F C78F C79F C84F C85F C86F: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL05A475MQ5NQNC
C10P C11C C11H C12P C14P C15P C16P C17C C17P C18P C20P C22C C22P C23P C24P C25P C29P C30P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL10A106MQ8NNNC
C11P C13P C19P C21P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL05B103KA5NNNC
C13C: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=DNP
C13D C35F C49D C49F C50F: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL31A107MQHNNNE
C13F C14F C18F C19F C26F C30F C31F C32F C33F C34F C39F C41F C42F C43F C44F C45F C51F C52F C53F C54F C55F C59F C60F C61F C62F C66F C67F C68F C69F C73F C74F C75F C76F C80F C81F C82F C83F: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL03A474KQ3NNNH
C22D C23D C24D C25D C31P C45D C46D C47D C48D: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL03A224MQ3NNNC
C26P C27P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL03A105KQ3CSNC
C28P C33P C38P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL21B104KBCNNWC
C32P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL31A106KBHNNNE
C34P C35P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL31A226KAHNNNE
C39P: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=CL05C750JB5NNNC
C51D: library part "Cap Semi", "Capacitor (Semiconductor SIM Model)", MPN=GRM0335C1H3R3CA01D
D10C: library part LED2, "Red LED", MPN=CB-2012QRC-P8
D10F D11F D11P D12F: library part LED2, "Typical RED, GREEN, YELLOW, AMBER GaAs LED", MPN=CB-2012QWC-P8
D10H D11H D12H D14H D15H D16H D17H D18H D19H D21H D22H D23H: MPN=RCLAMP0524PATCT
D10P: library part BIDIR_ESD, "Bidirectional zener diode, Vz 17.1V nom", MPN=PESD24VL1BA,115
D13H D20H: library part Tranzorb, "On Semi 5.0V standoff TVS diode"
F10H F11H: library part FUSE0805, "Murata 140mA fuse, 40mA hold"
J10H J11H J12H: library part "Header 19", "Molex HDMI connector, Type A", MPN=HDM19SW-4-L2-1R3HHCN
JP10P: library part PWR2.5, "Low Voltage Power Supply Connector", MPN=PJ-002AH-SMT-TR
L10P L11P L12P L13P: library part "Inductor Iron", "Magnetic-Core Inductor", MPN=LPS3008-561MRC
L14P: library part "Inductor Iron", "Magnetic-Core Inductor", MPN=MSS1038-223MLB
P10C: library part "Header 4", "Header, 4-Pin", MPN=DNP
P10F: library part "Header 2", "Header, 2-Pin", MPN=DNP
P10H: library part HDMI-TYPE-D, "HDMI Type D with through-hole mounts", MPN=0467651301
P11C: library part "Header 10X2", "Header, 10-Pin, Dual row", MPN=(ESQ/ESW)-110-(34/44/69)-(L/G)-D
P11H: "Header, 11-Pin, Dual row"
P12C P12H: library part USB_MINI-AB_1, "Micro USB B type connector", MPN=10103594-0001LF
P13H: library part CMP-0001-00031-1, "Golden finger, PCIeX4, Dual, Opposite, Pitch 1mm, 64-Position"
Q10H Q13H: library part MOSFET-P, "P-Channel MOSFET"
Q11H Q12H Q14H Q15H: library part MOSFET-N, "N-Channel MOSFET"
Q16H Q17H Q18H: library part MOSFET-N, "N-Channel MOSFET", MPN=BSS138LT1G
R10C R10D R10H R10P R11D R11F R11P R12D R12F R12P R13D R13F R13P R14D R14P R15F R15H R15P R16P R17C R17P R18C R18H R18P R19C R19P R20P R21C R21P R22C R22P R23P R24C R24P R25C R25P R26C R26H R26P R27P R28H R29P R30H R30P R31P R32H R37H R38H R39H R40H: library part Res1, "Resistor", MPN=ANY
R10F R16H R17H R20H R27H R29H R31H R34H: library part Res1, "Resistor", MPN=RS02U102FT
R11C R12C: library part Res1, "Resistor", MPN=RS02U472FT
R11H R12H R13H R14H R19H R21H R22H R25H: library part RPACK2, MPN=RP102PJ470CS
R13C R16C R33H: library part Res1, "Resistor", MPN=RS02U103FT
R14C R15C: library part Res1, "Resistor", MPN=RS02U330FT
R14F R32P: library part Res1, "Resistor", MPN=RS02U331FT
R16F R17F R18F R20C: library part Res1, "Resistor", MPN=RS02U101FT
R23C: library part Res1, "Resistor"
R23H: library part Res1, "Resistor", MPN=RS02U152FT
R24H R28P: library part Res1, "Resistor", MPN=DNP
R35H R36H R41H R42H R43H R44H: library part Res1, "Resistor", MPN=RS02U182FT
RP10D RP11D RP12D RP13D RP14D RP15D: library part RPACK4, MPN=RP104PJ390CS
SW10C: library part "Header 4", "Chi Fung TS-1187A", MPN=SW-PB-5X5-1.6
TP10H TP11H TP12H TP13H: library part CON1, "Connector"
U10C: library part EN25P05-50GCP, "64Mbit SPI NOR FLASH"
U10D U11D: "2Gb DDR3-1600 SDRAM, 128Mb x 16, 1.25ns, 1.5V, 0 to 95 degC, 96-Ball FBGA, Pb-Free", MPN=MT41J128M16JT-125:K, Op. Temp.="0C to +95C", Package=FBGA, Voltage=1.5V
U10F: "Artix-7 FPGA, 250 User I/Os, 4 GTP, 484-Ball BGA, Speed Grade 2, Commercial Grade, Pb-Free", Manufacturer=Xilinx, Operating Temperature Range=Commercial
U10H: library part 74AC04SC, "Hex Inverter, 14-Pin SOIC, Commercial Grade", MPN=74VHC04MTCX
U10P U11P U12P U13P: "2.4MHz, 5A TinyBuck Synchronous Buck Regulator"
U11C: library part MK22-64LQFP, "NXP K22F series 64LQFP device", MPN=MK22FN128VLH10
U11F: library part OSCILLATOR, "Abracon ASDMB Miniature Oscillator", MPN=ASDMB-50.000MHZ-LC-T
U14P: library part LP5907UVX, "Ultra low-noise 250mA LDO for RF and analog in DSBGA"
U15P: "2A-peak sink/source DDR termination regulator", MPN=TPS51206DSQ(T/R)
U16P: "4.5 to 28V input, 2A output, step down sync buck", MPN=TPS54202DDCT
Y10C: library part XTAL, "3.2 x 1.5mm 32.768 kHz crystal, 6pF CL 70k ESR, 20ppm", MPN=SJFC1332K06F20

## Free pads (board coordinates)
  round 2.5 hole 2.7 unplated mask+1.5: 0(23.5,26.5) 0(23.5,75.5) 0(81.5,26.5) 0(81.5,75.5)
  rect 2.489x0.051 on Bottom Overlay: 1(81.164,59.052) 1(81.164,59.103) 1(81.164,59.153) 1(83.45,61.439)
  rect 2.54x0.051 on Bottom Overlay: 1(81.189,58.798) 1(81.189,58.899) 1(81.189,58.95) 1(81.189,59.001) 1(81.189,59.204) 1(81.189,59.306) 1(81.189,59.357) 1(81.189,59.407) 1(81.189,58.849) 1(81.189,59.255) 1(81.291,59.611) 1(85.609,59.611) 1(85.711,58.849) 1(85.711,58.899) 1(85.711,58.95) 1(85.711,59.001) 1(85.711,59.052) 1(85.711,59.103) 1(85.711,59.153) 1(85.711,59.204) 1(85.711,59.255) 1(85.711,59.306) 1(85.711,59.357) 1(85.711,59.407)
  rect 2.591x0.051 on Bottom Overlay: 1(81.215,58.747) 1(81.215,59.458) 1(81.215,59.509) 1(81.215,59.56) 1(81.215,58.696) 1(81.266,58.645) 1(85.634,58.645) 1(85.685,58.696) 1(85.685,59.458) 1(85.685,58.747) 1(85.685,58.798) 1(85.685,59.509)
  rect 0.102x0.051 on Bottom Overlay: 1(81.291,61.897) 1(82.358,56.664) 1(84.542,56.664) 1(85.609,61.897)
  rect 0.254x0.051 on Bottom Overlay: 1(81.316,56.41) 1(81.316,61.846) 1(82.332,56.715) 1(84.568,56.715) 1(85.584,56.41) 1(85.584,61.846)
  rect 0.356x0.051 on Bottom Overlay: 1(81.316,56.461) 1(81.316,61.795) 1(82.282,56.766) 1(84.618,56.766) 1(85.584,61.795)
  rect 0.152x0.051 on Bottom Overlay: 1(81.316,56.359) 1(85.584,56.359)
  rect 0.457x0.051 on Bottom Overlay: 1(81.316,61.744)
  rect 0.508x0.051 on Bottom Overlay: 1(81.342,56.512) 1(85.558,56.512) 1(85.558,61.744)
  rect 0.61x0.051 on Bottom Overlay: 1(81.342,56.563) 1(81.342,61.693) 1(85.558,61.693)
  rect 0.711x0.051 on Bottom Overlay: 1(81.342,61.643)
  rect 0.762x0.051 on Bottom Overlay: 1(81.367,56.613) 1(85.533,56.613) 1(85.533,61.643)
  rect 0.864x0.051 on Bottom Overlay: 1(81.367,56.664) 1(81.367,61.592) 1(83.45,62.659) 1(85.533,56.664) 1(85.533,61.592)
  rect 0.965x0.051 on Bottom Overlay: 1(81.367,61.541) 1(83.45,62.506) 1(83.45,62.557) 1(83.45,62.608) 1(85.533,61.541)
  rect 1.016x0.051 on Bottom Overlay: 1(81.393,56.715) 1(83.425,62.455) 1(85.507,56.715)
  rect 2.337x0.051 on Bottom Overlay: 1(81.393,58.595) 1(82.155,60.119) 1(85.507,58.595)
  rect 1.219x0.051 on Bottom Overlay: 1(81.393,61.439) 1(83.425,61.897) 1(85.507,61.439)
  rect 1.118x0.051 on Bottom Overlay: 1(81.393,61.49) 1(81.393,56.766) 1(83.425,62.151) 1(85.507,61.49) 1(85.507,56.766)
  rect 2.286x0.051 on Bottom Overlay: 1(81.418,59.661) 1(84.72,60.119) 1(85.431,59.661)
  rect 2.134x0.051 on Bottom Overlay: 1(81.545,58.544) 1(82.053,60.068) 1(84.847,60.068) 1(85.355,58.544)
  rect 1.829x0.051 on Bottom Overlay: 1(81.596,56.918) 1(81.697,57.172) 1(81.748,57.274) 1(81.748,58.442) 1(81.748,59.763) 1(81.799,58.391) 1(81.799,59.814) 1(82.002,57.833) 1(82.002,57.883) 1(84.898,57.833) 1(84.898,57.883) 1(85.05,59.865) 1(85.101,57.325) 1(85.101,58.391) 1(85.101,58.442) 1(85.101,59.814) 1(85.152,57.223) 1(85.152,57.274) 1(85.152,59.763) 1(85.203,57.172) 1(85.304,56.918)
  rect 1.93x0.051 on Bottom Overlay: 1(81.596,56.969) 1(81.901,58.29) 1(81.901,59.966) 1(82.002,58.036) 1(82.002,57.985) 1(84.898,57.985) 1(84.898,58.036) 1(84.999,59.966) 1(84.999,58.29) 1(85.05,58.341) 1(85.304,56.969)
  rect 2.032x0.051 on Bottom Overlay: 1(81.596,59.712) 1(81.951,58.188) 1(82.002,58.087) 1(82.002,58.137) 1(84.898,58.087) 1(84.898,58.137) 1(84.898,58.188) 1(85.304,59.712)
  rect 1.778x0.051 on Bottom Overlay: 1(81.621,56.867) 1(81.774,57.325) 1(81.824,57.375) 1(81.824,57.426) 1(81.875,57.477) 1(81.926,57.579) 1(84.974,57.579) 1(85.025,57.477) 1(85.076,57.375) 1(85.076,57.426) 1(85.279,56.867)
  rect 1.88x0.051 on Bottom Overlay: 1(81.621,57.02) 1(81.621,57.071) 1(81.672,57.121) 1(81.723,58.493) 1(81.723,57.223) 1(81.824,58.341) 1(81.824,59.865) 1(81.875,59.915) 1(81.977,57.934) 1(84.872,57.934) 1(85.025,59.915) 1(85.177,58.493) 1(85.228,57.071) 1(85.228,57.121) 1(85.279,57.02)
  rect 1.676x0.051 on Bottom Overlay: 1(81.621,56.817) 1(81.977,57.68)
  rect 1.727x0.051 on Bottom Overlay: 1(81.901,57.528) 1(81.951,57.629) 1(82.002,57.731) 1(82.002,57.782) 1(83.425,61.592) 1(84.898,57.68) 1(84.898,57.731) 1(84.898,57.782) 1(84.949,57.629) 1(84.999,57.528) 1(85.253,56.817)
  rect 1.981x0.051 on Bottom Overlay: 1(81.926,58.239) 1(81.977,60.017) 1(83.45,61.541) 1(84.923,60.017) 1(84.974,58.239)
  rect 4.674x0.051 on Bottom Overlay: 1(83.425,60.576)
  rect 5.08x0.051 on Bottom Overlay: 1(83.425,60.881)
  rect 4.877x0.051 on Bottom Overlay: 1(83.425,60.728)
  rect 1.27x0.051 on Bottom Overlay: 1(83.45,61.693) 1(83.45,61.744) 1(83.45,61.795) 1(83.45,61.846)
  rect 4.826x0.051 on Bottom Overlay: 1(83.45,60.169) 1(83.45,60.22) 1(83.45,60.677)
  rect 4.724x0.051 on Bottom Overlay: 1(83.45,60.271) 1(83.45,60.627) 1(83.45,60.322)
  rect 4.623x0.051 on Bottom Overlay: 1(83.45,60.423) 1(83.45,60.474) 1(83.45,60.525) 1(83.45,60.373)
  rect 5.029x0.051 on Bottom Overlay: 1(83.45,60.83)
  rect 5.131x0.051 on Bottom Overlay: 1(83.45,60.931)
  rect 5.232x0.051 on Bottom Overlay: 1(83.45,60.982)
  rect 5.334x0.051 on Bottom Overlay: 1(83.45,61.033) 1(83.45,61.084)
  rect 5.537x0.051 on Bottom Overlay: 1(83.45,61.185) 1(83.45,61.236) 1(83.45,61.338)
  rect 5.639x0.051 on Bottom Overlay: 1(83.45,61.287)
  rect 5.436x0.051 on Bottom Overlay: 1(83.45,61.389) 1(83.45,61.135)
  rect 1.473x0.051 on Bottom Overlay: 1(83.45,61.643)
  rect 1.168x0.051 on Bottom Overlay: 1(83.45,61.947) 1(83.45,61.998) 1(83.45,62.049) 1(83.45,62.1)
  rect 1.067x0.051 on Bottom Overlay: 1(83.45,62.303) 1(83.45,62.354) 1(83.45,62.405) 1(83.45,62.201) 1(83.45,62.252)
  rect 4.928x0.051 on Bottom Overlay: 1(83.45,60.779)
  rect 2.184x0.051 on Bottom Overlay: 1(83.45,61.49)
  rect 0.66x0.051 on Bottom Overlay: 1(85.533,56.563)
  rect 0.406x0.051 on Bottom Overlay: 1(85.558,56.461)
  rect 2.642x0.051 on Bottom Overlay: 1(85.66,59.56)
  round 2.88 hole 3.18 unplated: MH1(7.25,9.35) MH2(7.5,94.75)

## Via types
v1: diameter 0.5, hole 0.25, L1 to L6, tented both sides, 789 vias
v2: diameter 0.45, hole 0.25, L1 to L6, tented both sides, 57 vias
v3: diameter 0.5, hole 0.25, L1 to L6, tented top, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
CEC: D10H.1 D10H.10 D14H.1 D14H.10 J10H.13 J11H.13 R15H.1 | length 46.2
  L1 w0.1: J11H.13@10.16,25.5 12.075,25.5 12.975,26.4 D14H.10@13.538,26.4 D14H.1@14.413,26.4 15.975,26.4 16.8,27.225 16.8,29.25 17.775,30.225 17.775,31.325 ; J10H.13@10.16,49.5 11.675,49.5 12.85,50.675 D10H.10@13.487,50.675 D10H.1@14.362,50.675 14.925,50.675 v1(15.575,50.025) ; v1(13.275,42.45) 13.275,41.675 14.5,40.45 14.5,34.95 17.775,31.675 17.775,31.325 ; v1(19.15,31.825) 18.65,31.325 17.775,31.325
  L3 w0.1: v1(13.275,42.45) 12.15,43.575 12.15,46.6 v1(15.575,50.025)
  L6 w0.1: v1(19.15,31.825) 19.85,32.525 R15H.1@23,32.525
CEC_R: R15H.2 U10F.P20 | length 5.3
  L1 w0.1: v1(27.522,34.757) U10F.P20@28.222,34.757
  L6 w0.1: R15H.2@24.2,32.525 25.3,32.525 25.9,33.125 26.575,33.125 27.508,34.058 27.508,34.743 v1(27.522,34.757)
DDC_SCL: D10H.2 D10H.9 D14H.2 D14H.9 J10H.15 J11H.15 U10H.5 | length 68.9
  L1 w0.1: J11H.15@10.16,26.5 11.95,26.5 12.35,26.9 D14H.9@13.538,26.9 D14H.2@14.413,26.9 15.925,26.9 16.425,27.4 16.425,29.475 17.225,30.275 17.225,31.7 14.15,34.775 14.15,40.24 v1(12.383,42.008) ; J10H.15@10.16,50.5 11.8,50.5 12.475,51.175 D10H.2@14.362,51.175 15.45,51.175 v1(16.45,50.175)
  L3 w0.1: v1(12.383,42.008) 11.85,42.54 11.85,48.175 14.25,50.575 16.05,50.575 v1(16.45,50.175) 16.45,51.275 16.7,51.525 16.7,52.35 16.45,52.6 15.7,52.6 15.15,53.15 15.15,53.725 19.45,58.025 19.45,63.8 21.15,65.5 23.55,65.5 23.75,65.3 24.275,65.3 24.725,65.75 v1(25.3,65.75)
  L6 w0.1: v1(25.3,65.75) U10H.5@25.3,68.475
DDC_SCL_LV_N: U10F.T18 U10H.6 | length 34.6
  L1 w0.1: v1(28.222,36.886) U10F.T18@28.222,37.586
  L4 w0.1: v1(25.95,66.95) 26.575,66.95 28.35,65.175 28.35,63.825 27.675,63.15 27.675,43.825 27.937,43.563 27.937,41.979 28.775,41.142 28.775,38.175 28.222,37.622 v1(28.222,36.886)
  L6 w0.1: v1(25.95,66.95) U10H.6@25.95,68.475
DDC_SDA: D10H.4 D10H.7 D14H.4 D14H.7 J10H.16 J11H.16 Q10H.3 R18H.2 U10H.13 | length 65.4
  L1 w0.1: J11H.16@10.16,27 11.7,27 12.1,27.4 12.1,27.575 12.425,27.9 D14H.7@13.538,27.9 D14H.4@14.413,27.9 15.225,27.9 16.025,28.7 Q10H.3@16.025,31.3 15.575,31.3 15.45,31.425 15.45,32.475 14.15,33.775 R18H.2@13.35,33.775 13.35,34.775 13.8,35.225 13.8,40.1 12.825,41.075 v1(12.15,41.075) ; J10H.16@10.16,51 11.55,51 12.125,51.575 12.125,51.9 12.4,52.175 D10H.7@13.487,52.175 D10H.4@14.362,52.175 15.375,52.175 16.8,50.75 v1(17.35,50.75)
  L3 w0.1: v1(12.15,41.075) 12.75,41.075 13.7,42.025 13.7,42.8 13.15,43.35 13.15,46.825 15.325,49 16.15,49 17.35,50.2 v1(17.35,50.75) 17.35,51.1 17,51.45 17,52.525 16.675,52.85 15.8,52.85 15.5,53.15 15.5,53.625 19.825,57.95 19.825,61.675 21.575,63.425 21.575,64.15 22.5,65.075 v1(23.35,65.075)
  L6 w0.1: U10H.13@23.35,62.775 v1(23.35,65.075)
DDC_SDA_LV_N: U10F.V18 U10H.12 | length 30.3
  L1 w0.1: U10F.V18@26.825,39 v1(27.525,39)
  L4 w0.1: v1(24,64.225) 24,62.65 25.875,60.775 25.875,46.8 24.675,45.6 24.675,41.05 26.725,39 v1(27.525,39)
  L6 w0.1: U10H.12@24,62.775 v1(24,64.225)
DDC_SDA_PD: Q12H.1 R20H.1 U10F.F20 | length 28.1
  L1 w0.1: v1(13.15,35.925) Q12H.1@13.15,37.375 R20H.1@13.15,38.7 ; v1(33.879,28.401) U10F.F20@33.879,29.101
  L4 w0.1: v1(13.15,35.925) 15.525,33.55 15.525,33.025 18.85,29.7 23.3,29.7 23.975,29.025 25.125,29.025 26.025,28.125 32,28.125 32.275,27.85 33.328,27.85 v1(33.879,28.401)
DDC_SDA_PU: Q11H.1 R17H.1 U10F.G20 | length 33.6
  L1 w0.1: R17H.1@5.85,35.4 6.225,35.775 Q11H.1@7.475,35.775 7.475,36.375 v1(8.225,37.125) ; v1(33.172,29.108) U10F.G20@33.172,29.808
  L4 w0.1: v1(8.225,37.125) 13.2,37.125 16.15,34.175 16.15,33 19.15,30 23.575,30 24.225,29.35 26.5,29.35 27.325,28.525 31.875,28.525 32.458,29.108 v1(33.172,29.108)
DDR3_A0: RP12D.5 U10D.N3 U10F.U6 U11D.N3 | length 59.6
  L1 w0.1: U10F.U6@36,46.778 v1(36,47.478) ; v2(61.277,55.963) 61.898,55.342 62.462,55.342 62.501,55.302 62.503,55.302 62.738,55.068 62.738,55.066 62.818,54.986 62.818,54.845 U11D.N3@63.15,54.513
  L3 w0.1: v1(36,47.478) 36,48.2 34.8,49.4 34.075,49.4 33.925,49.55 33.925,49.725 34.1,49.9 34.875,49.9 35.1,50.125 35.475,50.125 36.475,49.125 37.066,49.125 37.5,49.559 38.059,49.559 40.15,51.65 41.775,51.65 41.925,51.8 41.997,51.872 41.997,52.016 41.929,52.084 41.929,52.229 42.073,52.373 42.218,52.373 42.358,52.233 42.498,52.093 42.642,52.093 42.786,52.237 42.786,52.381 42.646,52.521 42.506,52.661 42.506,52.806 42.65,52.95 42.795,52.95 42.935,52.81 43.075,52.67 43.219,52.67 43.363,52.814 43.363,52.958 43.223,53.098 43.083,53.238 43.083,53.383 43.227,53.527 43.372,53.527 43.512,53.387 43.652,53.247 43.796,53.247 43.94,53.391 43.94,53.535 43.8,53.675 43.66,53.815 43.66,53.96 43.804,54.104 43.949,54.104 44.089,53.964 44.229,53.824 44.373,53.824 44.517,53.968 44.517,54.112 44.377,54.252 44.237,54.392 44.237,54.537 44.381,54.681 44.526,54.681 44.666,54.541 44.806,54.401 44.95,54.401 45.094,54.545 45.094,54.689 44.954,54.829 44.814,54.969 44.814,55.114 44.958,55.258 45.103,55.258 45.243,55.118 45.383,54.978 45.527,54.978 45.671,55.122 45.671,55.266 45.531,55.406 45.391,55.546 45.391,55.691 45.535,55.835 45.68,55.835 45.82,55.695 45.96,55.555 46.104,55.555 46.248,55.699 46.248,55.843 46.108,55.983 45.968,56.123 45.968,56.268 46.112,56.412 46.257,56.412 46.397,56.272 46.537,56.132 46.681,56.132 46.825,56.276 46.825,56.42 46.685,56.56 46.545,56.7 46.545,56.845 46.689,56.989 46.834,56.989 46.902,56.921 47.046,56.921 47.262,57.137 47.288,57.162 47.375,57.25 56.7,57.25 57.475,56.475 60.765,56.475 v2(61.277,55.963) 61.937,55.963 63.25,54.65 63.25,53.825 66.075,51 66.075,50.375 66.425,50.025 67.226,50.025 v1(67.476,50.275)
  L6 w0.1: U10D.N3@60.887,56.775 60.986,56.874 61.106,56.874 61.209,56.772 61.209,56.51 61.318,56.401 61.46,56.401 61.502,56.443 61.644,56.443 61.856,56.231 61.856,56.089 61.757,55.99 61.757,55.792 61.686,55.722 61.518,55.722 v2(61.277,55.963) ; v1(67.476,50.275) RP12D.5@68.002,49.748
DDR3_A1: RP12D.7 U10D.P7 U10F.V4 U11D.P7 | length 51.4
  L1 w0.1: U10F.V4@36.707,48.899 v1(36.707,49.599) ; U11D.P7@61.453,57.341 61.714,57.079 61.87,57.079 61.912,57.122 62.098,57.122 62.712,56.507 v2(62.854,56.507)
  L3 w0.1: v1(36.707,49.599) 36.707,50.282 38.75,52.325 39.525,52.325 39.65,52.45 39.722,52.522 39.722,52.666 39.654,52.734 39.654,52.879 39.798,53.023 39.943,53.023 40.083,52.883 40.223,52.743 40.367,52.743 40.511,52.887 40.511,53.031 40.371,53.171 40.231,53.311 40.231,53.456 40.375,53.6 40.52,53.6 40.66,53.46 40.8,53.32 40.944,53.32 41.088,53.464 41.088,53.608 40.948,53.748 40.808,53.888 40.808,54.033 40.952,54.177 41.097,54.177 41.237,54.037 41.377,53.897 41.521,53.897 41.665,54.041 41.665,54.185 41.525,54.325 41.385,54.465 41.385,54.61 41.529,54.754 41.674,54.754 41.814,54.614 41.954,54.474 42.098,54.474 42.242,54.618 42.242,54.762 42.102,54.902 41.962,55.042 41.962,55.187 42.106,55.331 42.251,55.331 42.391,55.191 42.531,55.051 42.675,55.051 42.819,55.195 42.819,55.339 42.679,55.479 42.539,55.619 42.539,55.764 42.683,55.908 42.828,55.908 42.968,55.768 43.108,55.628 43.252,55.628 43.396,55.772 43.396,55.916 43.256,56.056 43.116,56.196 43.116,56.341 43.26,56.485 43.405,56.485 43.545,56.345 43.685,56.205 43.829,56.205 43.973,56.349 43.973,56.493 43.833,56.633 43.693,56.773 43.693,56.918 43.837,57.062 43.982,57.062 44.122,56.922 44.262,56.782 44.406,56.782 44.55,56.926 44.55,57.07 44.482,57.138 44.482,57.282 44.612,57.412 45,57.8 58.075,57.8 58.65,57.225 62.136,57.225 v2(62.854,56.507) 63.8,55.561 63.8,54.475 66.525,51.75 66.625,51.75 67.4,50.975 v1(68.05,50.975)
  L6 w0.1: v2(62.854,56.507) 63.468,55.893 63.468,55.326 U10D.P7@63.716,55.078 ; v1(68.05,50.975) 68.275,50.75 68.61,50.75 RP12D.7@68.807,50.553
DDR3_A2: RP12D.8 U10D.P3 U10F.W5 U11D.P3 | length 51.4
  L1 w0.1: U10F.W5@35.293,48.899 v1(35.293,49.599) ; v2(63.667,56.373) 63.667,56.578 63.561,56.683 63.412,56.683 63.256,56.528 63.256,56.132 63.525,55.863 63.666,55.863 63.906,55.623 63.906,55.269 U11D.P3@63.716,55.078
  L4 w0.1: v1(35.293,49.599) 36.066,49.599 38.967,52.5 42,52.5 42.45,52.95 43.525,52.95 43.625,53.05 43.732,53.157 43.947,53.157 44.015,53.09 44.23,53.09 44.445,53.305 44.445,53.52 44.27,53.695 44.095,53.87 44.095,54.085 44.309,54.3 44.524,54.3 44.7,54.125 44.875,53.949 45.09,53.949 45.305,54.164 45.305,54.379 45.13,54.555 44.954,54.73 44.954,54.945 45.169,55.16 45.384,55.16 45.56,54.985 45.735,54.809 45.95,54.809 46.165,55.024 46.165,55.239 45.99,55.415 45.814,55.59 45.814,55.805 46.029,56.02 46.244,56.02 46.419,55.844 46.595,55.669 46.81,55.669 47.025,55.884 47.025,56.099 46.849,56.274 46.674,56.45 46.674,56.665 46.889,56.88 47.104,56.88 47.172,56.812 47.387,56.812 47.7,57.125 47.852,57.125 48.004,56.973 48.004,56.877 48.156,56.725 48.46,56.725 48.612,56.877 48.612,56.973 48.764,57.125 48.9,57.125 57.15,57.125 57.65,56.625 58.3,56.625 58.8,57.125 62.275,57.125 62.475,56.925 63.115,56.925 v2(63.667,56.373) 66.99,53.05 67.55,53.05 68.661,51.939 v1(68.661,51.6)
  L6 w0.1: U10D.P3@61.453,57.341 61.686,57.341 61.712,57.315 62.187,57.315 62.564,56.938 62.989,56.938 63.554,56.373 v2(63.667,56.373) ; v1(68.661,51.6) RP12D.8@69.258,51.004
DDR3_A3: RP13D.7 U10D.N2 U10F.V5 U11D.N2 | length 55.9
  L1 w0.1: U10F.V5@36,48.192 v1(36,48.892) ; v2(63.045,55.609) 63.045,56.004 62.946,56.103 62.676,56.104 62.577,56.005 62.577,55.511 62.918,55.17 63.163,55.17 63.317,55.015 63.317,54.882 63.544,54.655 63.742,54.655 63.906,54.491 63.906,54.138 U11D.N2@63.716,53.947 ; v1(66.7,51.1) 67.325,51.1 67.925,50.5 68.152,50.5 RP13D.7@68.453,50.199
  L4 w0.1: v1(36,48.892) 36,48.1 35.675,47.775 35.025,47.775 34.8,48 34.8,48.425 35.75,49.375 36.325,49.375 36.575,49.125 36.799,49.125 37.274,49.6 37.475,49.6 39.875,52 42.075,52 42.65,52.575 44.925,52.575 45.037,52.687 45.145,52.795 45.36,52.795 45.428,52.727 45.643,52.727 45.858,52.942 45.858,53.157 45.682,53.332 45.507,53.508 45.507,53.723 45.722,53.938 45.937,53.938 46.112,53.762 46.288,53.587 46.503,53.587 46.718,53.802 46.718,54.017 46.542,54.192 46.367,54.368 46.367,54.583 46.582,54.798 46.797,54.798 46.972,54.622 47.148,54.447 47.362,54.447 47.577,54.662 47.577,54.877 47.402,55.052 47.227,55.227 47.227,55.442 47.442,55.657 47.657,55.657 47.832,55.482 48.007,55.307 48.222,55.307 48.437,55.522 48.437,55.737 48.369,55.804 48.369,56.019 48.625,56.275 49.15,56.8 57.075,56.8 57.5,56.375 61.55,56.375 62.316,55.609 v2(63.045,55.609) 64.675,53.979 64.675,53.6 66.1,52.175 66.1,51.7 v1(66.7,51.1)
  L6 w0.1: U10D.N2@60.321,57.341 60.922,57.341 61.298,56.966 61.608,56.966 61.747,57.105 62.115,57.105 62.417,56.803 62.417,56.379 63.045,55.751 v2(63.045,55.609)
DDR3_A4: RP14D.5 U10D.P8 U10F.AA1 U11D.P8 | length 48.2
  L1 w0.1: U10F.AA1@36.707,53.142 v1(37.839,54.274) ; U11D.P8@60.887,57.907 61.077,58.097 61.657,58.097 61.898,58.338 62.188,58.338 62.429,58.097 62.739,58.097 63.146,58.504 63.544,58.504 64.141,57.907 v2(64.282,57.907)
  L3 w0.1: v1(37.839,54.274) 43.415,59.85 60,59.85 61.175,58.675 63.514,58.675 v2(64.282,57.907) 66.064,56.125 66.7,56.125 v1(68.875,53.95)
  L6 w0.1: U10D.P8@64.281,54.513 64.444,54.675 64.444,55.254 64.703,55.513 64.703,55.824 64.471,56.055 64.471,56.386 64.882,56.797 64.882,57.307 v2(64.282,57.907) ; v1(68.875,53.95) 68.875,53.9 69.45,53.325 69.45,52.8 70.027,52.223 RP14D.5@70.477,52.223
DDR3_A5: RP15D.7 U10D.P2 U10F.Y2 U11D.P2 | length 48
  L1 w0.1: U10F.Y2@36.707,51.728 36.707,52.425 v1(37.579,53.296) ; U11D.P2@64.281,54.513 64.488,54.305 64.633,54.305 64.774,54.447 64.774,54.588 64.467,54.896 64.26,54.896 64.161,54.995 64.161,55.143 64.26,55.242 64.448,55.242 64.704,55.498 64.704,55.791 64.387,56.108 64.387,56.312 64.558,56.482 64.558,56.642 64.459,56.741 v2(64.459,57.024) ; v1(69.95,52.9) 70.702,52.9 RP15D.7@70.928,52.674
  L4 w0.1: v1(37.579,53.296) 37.875,53 41.9,53 46.325,57.425 60.2,57.425 60.55,57.775 63.177,57.775 63.243,57.709 63.773,57.709 v2(64.459,57.024) 65.857,55.625 66.95,55.625 67.325,55.25 67.325,54.925 68.7,53.55 69.3,53.55 v1(69.95,52.9)
  L6 w0.1: U10D.P2@60.887,57.907 61.417,57.907 61.793,57.531 62.241,57.531 62.511,57.801 62.894,57.801 63.037,57.657 63.825,57.657 v2(64.459,57.024)
DDR3_A6: RP14D.7 U10D.R8 U10F.AB1 U11D.R8 | length 51.8
  L1 w0.1: U10F.AB1@36,53.849 v1(37.132,54.982) ; U11D.R8@61.453,58.472 61.453,59.011 62.628,60.186 62.793,60.186 62.957,60.023 62.957,59.684 63.115,59.526 63.296,59.526 63.758,59.988 63.932,59.988 64.14,59.781 64.53,59.781 v2(64.812,59.498)
  L3 w0.1: v1(37.132,54.982) 42.326,60.175 61.012,60.175 61.689,59.498 v2(64.812,59.498) 65.425,58.886 65.425,58.35 68.15,55.625 68.65,55.625 v1(69.625,54.65)
  L6 w0.1: v2(64.812,59.498) 65.468,58.843 65.468,58.277 65.826,57.919 65.826,56.616 64.995,55.785 64.995,55.227 U10D.R8@64.847,55.078 ; v1@69.8,54.5 70.275,54.025 70.95,54.025 71.134,53.841 71.134,53.175 RP14D.7@71.282,53.028
DDR3_A7: RP15D.6 U10D.R2 U10F.AB3 U11D.R2 | length 50.1
  L1 w0.1: U10F.AB3@34.586,52.435 v1(34.586,53.135) ; U11D.R2@64.847,55.078 65.01,55.241 65.01,55.8 65.605,56.395 65.605,57.999 v2(64.989,58.615) ; v1(70.675,53.625) 70.684,53.625 RP15D.6@71.282,53.028
  L4 w0.1: v1(34.586,53.135) 35.11,53.135 36.05,54.075 36.925,54.075 37.625,54.775 46.4,58.225 55.616,58.225 56.191,58.8 59.428,58.8 59.678,58.55 60.3,58.55 60.475,58.725 64.525,58.725 64.635,58.615 v2(64.989,58.615) 68.277,55.327 69.548,55.327 70.05,54.825 70.05,54.25 v1(70.675,53.625) v1@70.7,53.625
  L6 w0.1: U10D.R2@61.453,58.472 61.615,58.635 62.167,58.635 62.758,59.226 64.377,59.226 v2(64.989,58.615)
DDR3_A8: RP15D.5 U10D.T8 U10F.AB2 U11D.T8 | length 49.4
  L1 w0.1: U10F.AB2@35.293,53.142 35.293,53.839 v1(36.164,54.711) ; U11D.T8@62.018,59.038 62.218,59.238 64.358,59.238 64.525,59.07 65.241,59.07 v2(65.873,58.438) ; v1@70.718,54.493 RP15D.5@71.732,53.478
  L4 w0.1: v1(36.164,54.711) 36.979,55.525 47.3,59.025 58.825,59.025 59.175,59.375 60.2,59.375 60.452,59.123 65.187,59.123 v2(65.873,58.438) 68.6,55.711 69.514,55.711 v1(70.6,54.625)
  L6 w0.1: U10D.T8@65.413,55.644 66.166,56.398 66.166,58.133 66.508,58.475 66.508,58.616 66.35,58.774 66.209,58.774 v2(65.873,58.438)
DDR3_A9: RP15D.8 U10D.R3 U10F.Y3 U11D.R3 | length 51.7
  L1 w0.1: U10F.Y3@36,51.021 v1(36,51.721) ; v2(63.398,58.084) 64.004,57.478 64.004,56.734 64.178,56.56 64.178,55.746 64.28,55.644 U11D.R3@64.281,55.644 ; v1(69.05,53.1) 69.927,52.223 RP15D.8@70.477,52.223
  L3 w0.1: v1(36,51.721) 35.279,51.721 34.05,52.95 34.05,53.4 34.5,53.85 38.04,53.85 43.24,59.05 54.25,59.05 54.375,58.925 54.975,58.925 55.1,59.05 55.7,59.05 55.875,58.875 56.6,58.875 56.775,59.05 57.975,59.05 58.3,59.375 60.125,59.375 61.2,58.3 62.758,58.3 62.974,58.084 v2(63.398,58.084) 64.05,57.432 64.05,56.875 65.825,55.1 66.3,55.1 67.3,54.1 68.05,54.1 v1(69.05,53.1)
  L6 w0.1: U10D.R3@62.018,57.907 61.956,57.845 61.799,57.845 61.648,57.996 61.648,58.108 61.963,58.422 62.084,58.422 62.446,58.061 62.728,58.061 62.991,58.324 63.158,58.324 v2(63.398,58.084)
DDR3_A10: RP10D.8 U10D.L7 U10F.W6 U11D.L7 | length 53.2
  L1 w0.1: U10F.W6@34.586,48.192 v1(34.586,48.892) ; U11D.L7@59.756,55.644 59.897,55.785 60.747,55.785 v2(61.454,55.079)
  L3 w0.1: v1(34.586,48.892) 34.586,48.214 35.725,47.075 36.163,47.075 36.4,47.312 37.565,48.477 37.593,48.477 38.936,49.82 38.936,49.849 39.287,50.2 39.538,50.45 40.238,50.45 40.938,51.15 42.675,51.15 42.725,51.2 42.797,51.272 42.797,51.416 42.729,51.484 42.729,51.629 42.873,51.773 43.018,51.773 43.158,51.633 43.298,51.493 43.442,51.493 43.586,51.637 43.586,51.781 43.446,51.921 43.306,52.061 43.306,52.206 43.45,52.35 43.595,52.35 43.735,52.21 43.875,52.07 44.019,52.07 44.163,52.214 44.163,52.358 44.023,52.498 43.883,52.638 43.883,52.783 44.027,52.927 44.172,52.927 44.312,52.787 44.452,52.647 44.596,52.647 44.74,52.791 44.74,52.935 44.6,53.075 44.46,53.215 44.46,53.36 44.604,53.504 44.749,53.504 44.889,53.364 45.029,53.224 45.173,53.224 45.317,53.368 45.317,53.512 45.177,53.652 45.037,53.792 45.037,53.937 45.181,54.081 45.326,54.081 45.466,53.941 45.606,53.801 45.75,53.801 45.894,53.945 45.894,54.089 45.754,54.229 45.614,54.369 45.614,54.514 45.758,54.658 45.903,54.658 46.043,54.518 46.183,54.378 46.327,54.378 46.471,54.522 46.471,54.666 46.331,54.806 46.191,54.946 46.191,55.091 46.335,55.235 46.48,55.235 46.62,55.095 46.76,54.955 46.904,54.955 47.048,55.099 47.048,55.243 46.98,55.311 46.98,55.455 47.162,55.637 48.35,56.825 56.725,56.825 57.396,56.154 60.379,56.154 v2(61.454,55.079) 63.725,52.808 63.725,51.8 v1(65.8,49.725)
  L6 w0.1: v2(61.454,55.079) 62.161,54.371 62.161,53.524 U10D.L7@62.018,53.381 ; v1(65.8,49.725) 66,49.525 66.425,49.525 66.783,49.167 RP10D.8@66.783,48.529
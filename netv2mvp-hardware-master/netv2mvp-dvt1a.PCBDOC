# Altium PCB netv2mvp-dvt1a.PCBDOC (part 3 of 6)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 90 x 100 mm, 6 copper layers (L1, L2, L3, L4, L5, L6), stack 1.542 mm thick; 329 components, 277 nets, 2092 pads, 848 vias.

## Via types
v1: diameter 0.5, hole 0.25, L1 to L6, tented both sides, 789 vias
v2: diameter 0.45, hole 0.25, L1 to L6, tented both sides, 57 vias
v3: diameter 0.5, hole 0.25, L1 to L6, tented top, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
DDR3_A11: RP13D.5 U10D.R7 U10F.Y1 U11D.R7 | length 47.1
  L1 w0.1: U10F.Y1@37.414,52.435 37.779,52.8 40.325,52.8 40.575,53.05 40.575,53.35 40.358,53.567 v1(38.547,53.567) ; U11D.R7@62.019,57.907 62.301,57.907 62.376,57.832 62.926,57.832 63.071,57.688 63.228,57.688 63.368,57.548 63.368,57.408 v2(63.575,57.2) ; v1@68.65,52.675 v1(68.575,52.6) 68.55,52.575 68.55,52.325 69.258,51.617 RP13D.5@69.258,51.004
  L3 w0.1: v1(38.547,53.567) 43.604,58.625 53.25,58.625 53.65,58.225 55.875,58.225 56.237,58.588 58.113,58.588 58.475,58.95 59.278,58.95 60.128,58.1 62.675,58.1 v2(63.575,57.2)
  L4 w0.1: v2(63.575,57.2) 65.6,55.175 66.125,55.175 67.75,53.55 67.975,53.55 68.575,52.95 v1(68.575,52.6)
  L6 w0.1: v2(63.575,57.2) 63.778,56.997 63.92,56.997 64.271,56.645 64.271,55.654 U10D.R7@64.281,55.644
DDR3_A12: RP13D.6 U10D.N7 U10F.V2 U11D.N7 | length 49.7
  L1 w0.1: U10F.V2@38.121,50.314 v1(38.121,51.013) ; U11D.N7@60.887,56.775 61.12,57.009 61.276,57.009 61.508,56.777 61.508,56.58 61.9,56.188 62.209,56.188 62.323,56.302 62.323,56.507 62.159,56.67 v2(61.984,56.67) ; v1(67.95,52.075) 67.95,51.7 68.6,51.05 68.6,50.76 RP13D.6@68.807,50.553
  L3 w0.1: v1(38.121,51.013) 38.672,51.013 39.8,52.142 40.792,52.142 40.875,52.225 40.947,52.297 40.947,52.441 40.879,52.509 40.879,52.654 41.023,52.798 41.168,52.798 41.308,52.658 41.448,52.518 41.592,52.518 41.736,52.662 41.736,52.806 41.596,52.946 41.456,53.086 41.456,53.231 41.6,53.375 41.745,53.375 41.885,53.235 42.025,53.095 42.169,53.095 42.313,53.239 42.313,53.383 42.173,53.523 42.033,53.663 42.033,53.808 42.177,53.952 42.322,53.952 42.462,53.812 42.602,53.672 42.746,53.672 42.89,53.816 42.89,53.96 42.75,54.1 42.61,54.24 42.61,54.385 42.754,54.529 42.899,54.529 43.039,54.389 43.179,54.249 43.323,54.249 43.467,54.393 43.467,54.537 43.327,54.677 43.187,54.817 43.187,54.962 43.331,55.106 43.476,55.106 43.616,54.966 43.756,54.826 43.9,54.826 44.044,54.97 44.044,55.114 43.904,55.254 43.764,55.394 43.764,55.539 43.908,55.683 44.053,55.683 44.193,55.543 44.333,55.403 44.477,55.403 44.621,55.547 44.621,55.691 44.481,55.831 44.341,55.971 44.341,56.116 44.485,56.26 44.63,56.26 44.77,56.12 44.91,55.98 45.054,55.98 45.198,56.124 45.198,56.268 45.058,56.408 44.918,56.548 44.918,56.693 45.062,56.837 45.207,56.837 45.275,56.769 45.419,56.769 45.512,56.862 46.175,57.525 57.975,57.525 58.65,56.85 61.378,56.85 61.558,56.67 v2(61.984,56.67)
  L4 w0.1: v2(61.984,56.67) 62.604,56.05 63.375,56.05 66.913,52.513 67.513,52.513 v1(67.95,52.075)
  L6 w0.1: v2(61.984,56.67) 61.984,56.529 62.599,55.913 62.599,55.489 63.15,54.938 U10D.N7@63.15,54.513
DDR3_A13: RP14D.6 U10D.T3 U10F.AA3 U11D.T3 | length 46.8
  L1 w0.1: U10F.AA3@35.293,51.728 v1(35.293,52.428) ; U11D.T3@64.847,56.21 65.338,56.7 65.338,56.846 64.73,57.453 64.73,57.92 64.923,58.113 65.06,58.113 65.166,58.008 v2(65.166,57.731)
  L4 w0.1: v1@35.39,52.525 35.49,52.425 36.025,52.425 37.35,53.75 38.05,53.75 38.475,54.175 46.325,57.75 56.05,57.75 56.575,58.275 58.822,58.275 59.197,57.9 60.2,57.9 60.759,58.459 64.437,58.459 v2(65.166,57.731) 68.371,54.525 69.077,54.525 69.802,53.8 v1(69.825,53.8)
  L6 w0.1: U10D.T3@62.584,58.472 62.727,58.615 63.585,58.615 63.852,58.349 64.406,58.349 65.024,57.731 v2(65.166,57.731) ; v1(69.825,53.8) 69.825,53.777 RP14D.6@70.928,52.674
DDR3_BA0: RP13D.8 U10D.M2 U10F.U5 U11D.M2 | length 52.8
  L1 w0.1: U10F.U5@36.707,47.485 v1(36.707,48.185) ; v2(62.337,54.902) 62.005,54.902 61.891,54.788 61.891,54.636 62.057,54.47 62.655,54.47 63.595,53.53 63.595,53.295 63.505,53.204 63.327,53.204 U11D.M2@63.15,53.381 ; v1(66.725,50.425) 67.402,49.748 RP13D.8@68.002,49.748
  L4 w0.1: v1(36.707,48.185) 36.707,48.751 37.264,49.307 37.557,49.307 39.75,51.5 42.175,51.5 42.9,52.225 46.2,52.225 50.425,56.45 56.975,56.45 57.35,56.075 60.4,56.075 60.975,55.5 61.74,55.5 61.89,55.35 62.575,55.35 64.2,53.725 64.2,53.425 63.9,53.125 63.525,53.125 62.337,54.313 v2(62.337,54.902) 62.025,54.59 62.025,53.625 62.425,53.225 62.725,53.225 63.438,52.512 63.438,52.212 65.225,50.425 v1(66.725,50.425)
  L6 w0.1: U10D.M2@59.756,56.775 60.319,56.775 60.877,56.217 60.877,55.797 61.193,55.481 61.758,55.481 v2(62.337,54.902)
DDR3_BA1: RP12D.6 U10D.N8 U10F.W4 U11D.N8 | length 56.3
  L1 w0.1: U10F.W4@36,49.607 v1(36,50.306) ; U11D.N8@60.321,57.341 60.321,57.143 60.438,57.026 60.58,57.026 60.739,57.185 60.739,57.292 60.951,57.504 61.057,57.504 61.382,57.829 61.566,57.829 61.973,57.422 62.08,57.422 62.586,56.917 62.909,56.917 63.129,57.136 63.129,57.334 62.959,57.504 62.818,57.504 v2(62.691,57.377)
  L3 w0.1: v1(36,50.306) 35.531,50.775 33.375,50.775 33.175,50.975 33.175,51.15 33.313,51.287 36.337,51.287 38.15,53.1 38.8,53.1 43.933,58.233 53.175,58.233 53.383,58.025 56.167,58.025 56.375,58.233 58.863,58.233 59.672,57.425 62.643,57.425 v2(62.691,57.377) 63.275,56.793 63.832,56.793 64.137,56.488 64.137,55.287 67.278,52.147 v1(67.278,51.678)
  L6 w0.1: v2(62.691,57.377) 62.832,57.377 63.413,56.797 63.837,56.797 64.071,56.563 64.071,56.212 63.882,56.023 63.882,55.456 64.126,55.213 64.126,54.916 63.716,54.506 U10D.N8@63.716,53.947 ; v1(67.278,51.678) 67.278,51.147 67.925,50.5 68.152,50.5 RP12D.6@68.453,50.199
DDR3_BA2: RP11D.6 U10D.M3 U10F.V7 U11D.M3 | length 55.9
  L1 w0.1: U10F.V7@34.586,46.778 v1(34.586,47.478) ; v2(61.63,54.195) 61.63,53.912 61.772,53.771 61.913,53.771 61.983,53.841 62.125,53.841 62.521,53.445 62.662,53.445 62.959,53.742 62.959,53.883 62.86,53.982 62.62,53.982 U11D.M3@62.584,53.947 ; v1(65.3,48.25) 66.16,48.25 RP11D.6@66.332,48.078
  L4 w0.1: v1(34.586,47.478) 35.025,47.478 35.225,47.278 35.225,46.825 35.55,46.5 36.125,46.5 36.3,46.675 36.407,46.782 36.407,46.997 36.345,47.06 36.345,47.275 36.56,47.49 36.775,47.49 36.945,47.32 37.12,47.145 37.335,47.145 37.55,47.359 37.55,47.574 37.375,47.75 37.199,47.925 37.199,48.14 37.414,48.355 37.629,48.355 37.697,48.287 37.912,48.287 38.025,48.4 38.025,48.75 38.65,49.375 38.65,49.875 39.925,51.15 42.525,51.15 43.225,51.85 47.325,51.85 47.462,51.987 47.57,52.095 47.57,52.31 47.502,52.378 47.502,52.593 47.717,52.808 47.932,52.808 48.107,52.632 48.283,52.457 48.498,52.457 48.713,52.672 48.713,52.887 48.537,53.062 48.362,53.238 48.362,53.453 48.577,53.668 48.792,53.668 48.967,53.492 49.143,53.317 49.358,53.317 49.573,53.532 49.573,53.747 49.397,53.922 49.222,54.098 49.222,54.312 49.437,54.527 49.652,54.527 49.827,54.352 50.002,54.177 50.217,54.177 50.432,54.392 50.432,54.607 50.257,54.782 50.082,54.957 50.082,55.172 50.297,55.387 50.512,55.387 50.687,55.212 50.862,55.037 51.077,55.037 51.292,55.252 51.292,55.466 51.224,55.534 51.224,55.749 51.547,56.072 51.675,56.2 51.827,56.2 51.979,56.048 51.979,55.952 51.979,55.346 52.125,55.2 52.475,55.2 52.587,55.312 52.587,55.952 52.587,56.048 52.739,56.2 53.175,56.2 56.825,56.2 57.225,55.8 59.35,55.8 60.3,54.85 60.975,54.85 v2(61.63,54.195) 61.63,53.445 62.25,52.825 62.65,52.825 63.05,52.425 63.05,51.8 64.3,50.55 64.3,49.075 64.75,48.625 64.925,48.625 v1(65.3,48.25)
  L6 w0.1: U10D.M3@60.321,56.21 60.569,55.962 60.569,55.822 61.007,55.384 61.007,54.818 v2(61.63,54.195)
DDR3_CAS_N: RP10D.6 U10D.K3 U10F.Y7 U11D.K3 | length 55.3
  L1 w0.1: U10F.Y7@33.172,48.192 v1(33.172,48.892) ; v2(60.923,53.488) 60.683,53.728 60.583,53.728 60.442,53.586 60.442,53.318 60.751,53.009 61.009,53.009 61.206,53.205 61.381,53.205 61.545,53.042 61.545,52.907 U11D.K3@61.453,52.816
  L4 w0.1: v1(33.172,48.892) 33.675,49.396 33.675,50.125 33.125,50.675 32.375,50.675 31.875,50.175 31.875,49.475 35.775,45.575 36.15,45.575 38.425,47.85 38.425,48.625 38.975,49.175 38.975,49.675 40.133,50.833 42.958,50.833 43.625,51.5 48.475,51.5 51.925,54.95 53.679,54.95 54.7,55.971 56.7,55.971 57.183,55.487 58.262,55.487 ; 58.275,55.5 59.575,54.2 60.211,54.2 v2(60.923,53.488) 62.025,52.386 62.025,52.225 63.925,50.325 63.925,48.825 v1(64.275,48.475)
  L6 w0.1: U10D.K3@59.19,55.078 59.462,54.807 59.462,54.525 59.838,54.148 60.263,54.148 v2(60.923,53.488) ; v1(64.275,48.475) 64.35,48.475 64.975,47.85 65.853,47.85 RP10D.6@65.978,47.724
DDR3_CK_N: C51D.1 R13D.1 U10D.K7 U10F.R2 U11D.K7 | length 51.1
  L1 w0.1: v1(39.543,48.192) U10F.R2@40.243,48.192 ; U11D.K7@59.19,55.078 59.19,54.115 58.809,53.734 58.809,53.474 59.105,53.177 59.395,53.177 v2(59.474,53.099) ; v1(63.175,46.525) 64.176,45.524 R13D.1@64.601,45.524
  L3 w0.1: v2(59.474,53.099) 59.474,52.816 60.425,51.865 60.425,50.575 61.05,49.95 61.5,49.95 61.825,49.625 61.825,47.575 62.675,46.725 62.975,46.725 v1(63.175,46.525)
  L4 w0.1: v1(39.543,48.192) 39.326,47.975 39,47.975 38.8,48.175 38.8,48.5 39.075,48.775 39.925,48.775 40.175,49.025 40.175,49.783 40.667,50.275 43.068,50.275 43.329,50.014 43.329,49.718 43.472,49.575 43.794,49.575 43.937,49.718 43.937,50.714 44.198,50.975 44.684,50.975 44.945,50.714 44.945,49.718 45.088,49.575 45.41,49.575 45.553,49.718 45.553,50.714 45.814,50.975 46.3,50.975 46.561,50.714 46.561,49.718 46.704,49.575 47.026,49.575 47.169,49.718 47.169,50.714 47.43,50.975 47.916,50.975 48.177,50.714 48.177,49.718 48.32,49.575 48.642,49.575 48.785,49.718 48.785,50.014 49.046,50.275 49.325,50.275 49.515,50.465 49.515,50.668 49.306,50.877 49.306,51.246 49.65,51.59 50.019,51.59 50.651,50.958 50.854,50.958 51.081,51.185 51.081,51.388 50.944,51.525 50.944,51.894 51.525,52.475 53.6,54.55 57.74,54.55 59.191,53.099 v2(59.474,53.099)
  L6 w0.1: v2(59.474,53.099) 61.169,53.099 U10D.K7@61.453,52.816 U10D.K7@61.412,52.775
DDR3_CK_P: C51D.2 R12D.1 U10D.J7 U10F.R3 U11D.J7 | length 51.5
  L1 w0.1: v1(38.836,47.485) U10F.R3@39.536,47.485 ; U11D.J7@58.624,54.513 58.5,54.637 58.5,54.825 58.6,54.925 58.775,54.925 58.99,54.71 58.99,54.198 58.609,53.817 58.609,53.366 59.049,52.926 v2(59.049,52.675) ; v1(62.775,46.05) 63.751,45.074 R12D.1@63.751,44.674
  L3 w0.1: v2(59.049,52.675) 59.332,52.675 60.225,51.782 60.225,50.492 60.909,49.809 60.909,49.4 61.259,49.05 61.55,49.05 61.625,48.975 61.625,47.492 62.567,46.55 62.567,46.258 v1(62.775,46.05)
  L4 w0.1: v1(38.836,47.485) 39.485,47.485 40.375,48.375 40.375,49.7 40.75,50.075 42.986,50.075 43.129,49.932 43.129,49.636 43.39,49.375 43.876,49.375 44.137,49.636 44.137,50.632 44.28,50.775 44.602,50.775 44.745,50.632 44.745,49.636 45.006,49.375 45.492,49.375 45.753,49.636 45.753,50.632 45.896,50.775 46.218,50.775 46.361,50.632 46.361,49.636 46.622,49.375 47.108,49.375 47.369,49.636 47.369,50.632 47.512,50.775 47.834,50.775 47.977,50.632 47.977,49.636 48.238,49.375 48.724,49.375 48.985,49.636 48.985,49.932 49.128,50.075 49.408,50.075 49.715,50.382 49.715,50.751 49.506,50.96 49.506,51.163 49.733,51.39 49.936,51.39 50.568,50.758 50.937,50.758 51.281,51.102 51.281,51.471 51.144,51.608 51.144,51.811 53.683,54.35 57.657,54.35 59.049,52.958 v2(59.049,52.675)
  L6 w0.1: v2(59.049,52.675) 59.074,52.65 59.6,52.65 59.849,52.899 60.801,52.899 61,52.7 61,52.363 U10D.J7@60.887,52.25
DDR3_CKE: RP10D.7 U10D.K9 U10F.Y8 U11D.K9 | length 57.2
  L1 w0.1: U10F.Y8@32.464,47.485 v1(32.464,48.185) ; U11D.K9@58.059,56.21 58.249,56.019 58.249,55.489 58.47,55.269 58.779,55.269 59,55.489 59.001,55.495 59.341,55.495 59.793,55.044 60.074,55.044 v2(60.746,54.372)
  L3 w0.1: v1(32.464,48.185) 32.464,47.486 33.8,46.15 33.949,46.15 35.127,44.972 35.622,44.972 40.75,50.1 41.45,50.1 41.725,50.375 44.7,50.375 44.912,50.587 44.985,50.66 44.985,50.804 44.917,50.872 44.917,51.016 45.061,51.16 45.205,51.16 45.345,51.02 45.485,50.88 45.629,50.88 45.774,51.025 45.774,51.169 45.634,51.309 45.494,51.449 45.494,51.593 45.638,51.737 45.782,51.737 45.922,51.597 46.062,51.457 46.206,51.457 46.351,51.602 46.351,51.746 46.211,51.886 46.071,52.026 46.071,52.17 46.215,52.314 46.359,52.314 46.499,52.174 46.639,52.034 46.783,52.034 46.928,52.179 46.928,52.323 46.788,52.463 46.648,52.603 46.648,52.747 46.792,52.891 46.936,52.891 47.076,52.751 47.216,52.611 47.36,52.611 47.505,52.756 47.505,52.9 47.365,53.04 47.225,53.18 47.225,53.324 47.369,53.468 47.513,53.468 47.653,53.328 47.793,53.188 47.937,53.188 48.082,53.332 48.082,53.477 48.014,53.545 48.014,53.689 48.15,53.825 50.325,56 56.725,56 57.225,55.5 59.618,55.5 v2(60.746,54.372) 60.975,54.143 60.975,54 62.15,52.825 62.15,52.05 64.575,49.625 64.9,49.625 65.2,49.325 65.2,49.15 65.415,48.935 v1(65.475,48.935)
  L6 w0.1: v2(60.746,54.372) 61.323,53.795 61.323,53.475 61.828,52.97 61.828,52.639 61.601,52.413 61.601,52.13 61.898,51.833 62.436,51.833 ; v1(65.475,48.935) RP10D.7@66.332,48.078
DDR3_CS0_N: RP10D.5 U10D.L2 U10F.V9 U11D.L2 | length 58.9
  L1 w0.1: U10F.V9@33.172,45.364 v1@33.172,46.064 ; v2(59.933,54.619) 60.581,53.972 61.005,53.972 61.643,53.334 61.643,53.226 62.054,52.816 U11D.L2@62.584,52.816
  L3 w0.1: v1(33.172,46.1) 34.148,45.123 34.693,45.123 35.291,44.525 36.6,44.525 42.05,49.975 45.725,49.975 45.8,50.05 45.872,50.122 45.872,50.266 45.804,50.334 45.804,50.479 45.948,50.623 46.093,50.623 46.233,50.483 46.373,50.343 46.517,50.343 46.661,50.487 46.661,50.631 46.521,50.771 46.381,50.911 46.381,51.056 46.525,51.2 46.67,51.2 46.81,51.06 46.95,50.92 47.094,50.92 47.238,51.064 47.238,51.208 47.098,51.348 46.958,51.488 46.958,51.633 47.102,51.777 47.247,51.777 47.387,51.637 47.527,51.497 47.671,51.497 47.815,51.641 47.815,51.785 47.675,51.925 47.535,52.065 47.535,52.21 47.679,52.354 47.824,52.354 47.964,52.214 48.104,52.074 48.248,52.074 48.392,52.218 48.392,52.362 48.252,52.502 48.112,52.642 48.112,52.787 48.256,52.931 48.401,52.931 48.541,52.791 48.681,52.651 48.825,52.651 48.969,52.795 48.969,52.939 48.829,53.079 48.689,53.219 48.689,53.364 48.833,53.508 48.978,53.508 49.118,53.368 49.258,53.228 49.402,53.228 49.546,53.372 49.546,53.516 49.406,53.656 49.266,53.796 49.266,53.941 49.41,54.085 49.555,54.085 49.695,53.945 49.835,53.805 49.979,53.805 50.123,53.949 50.123,54.093 49.983,54.233 49.843,54.373 49.843,54.518 49.987,54.662 50.132,54.662 50.2,54.594 50.344,54.594 50.425,54.675 50.527,54.675 50.629,54.573 50.629,54.477 50.731,54.375 50.935,54.375 51.037,54.477 51.037,54.675 51.037,54.873 51.139,54.975 51.343,54.975 51.445,54.873 51.445,54.675 51.545,54.575 51.753,54.575 51.853,54.675 51.853,54.873 51.955,54.975 52.159,54.975 52.261,54.873 52.261,54.675 52.361,54.575 52.569,54.575 52.669,54.675 52.875,54.675 53.2,55 53.475,55 54.125,55.65 54.55,55.65 55.75,54.45 56.74,54.45 56.91,54.619 v2(59.933,54.619) 60.525,54.028 60.525,53.25 63.625,50.15 63.625,48.55 v1(64.6,47.575)
  L6 w0.1: U10D.L2@59.19,56.21 59.317,56.337 59.317,56.478 59.183,56.613 58.992,56.613 58.723,56.344 58.723,56.139 59.01,55.853 59.01,55.598 59.148,55.46 59.409,55.46 59.933,54.936 v2(59.933,54.619) ; v1(64.6,47.575) 64.901,47.274 RP10D.5@65.528,47.274
DDR3_DM0: U10F.G1 U11D.E7 | length 23.4
  L1 w0.1: U10F.G1@46.607,43.243 46.839,43.475 48.05,43.475 48.25,43.675 48.25,43.875 48.125,44 47,44 46.887,44.113 46.887,44.312 46.96,44.385 46.96,44.529 46.75,44.738 46.75,44.882 46.895,45.027 47.039,45.027 47.32,44.745 47.602,44.464 47.746,44.464 47.89,44.608 47.89,44.752 47.609,45.034 47.327,45.315 47.327,45.459 47.472,45.604 47.616,45.604 47.897,45.322 48.179,45.041 48.323,45.041 48.467,45.185 48.467,45.329 48.186,45.611 47.904,45.892 47.904,46.036 48.049,46.181 48.193,46.181 48.474,45.899 48.756,45.618 48.9,45.618 49.044,45.762 49.044,45.906 48.763,46.188 48.481,46.469 48.481,46.613 48.626,46.758 48.77,46.758 48.979,46.548 49.123,46.548 49.25,46.675 49.375,46.675 52.275,46.675 55.675,50.075 55.675,50.825 56.362,51.512 U11D.E7@56.362,52.25
DDR3_DM1: U10F.H4 U11D.D3 | length 19.5
  L1 w0.1: U10F.H4@43.778,41.828 v1(43.778,42.528) ; U11D.D3@58.059,49.421 v2(58.627,49.421)
  L3 w0.1: v1(43.778,42.528) 43.778,43.478 46.9,46.6 51,46.6 53.821,49.421 v2(58.627,49.421)
DDR3_DM2: U10D.E7 U10F.M5 | length 25
  L1 w0.1: v1(40.243,43.25) U10F.M5@40.243,43.95
  L4 w0.1: v1(40.243,43.25) 40.875,43.25 41.35,42.775 41.9,42.775 42.125,43 42.125,43.525 41.925,43.725 41.925,44.15 42.15,44.375 45.1,44.375 45.807,45.082 46.575,45.082 47.407,44.25 51.275,44.25 57.012,49.987 v2(59.193,49.987)
  L6 w0.1: U10D.E7@58.624,49.987 v2(59.193,49.987)
DDR3_DM3: U10D.D3 U10F.L3 | length 19
  L1 w0.1: U10F.L3@42.364,44.657 42.93,44.657 44.237,45.964 44.356,45.964 45.125,46.733 v1@45.125,48.625
  L6 w0.1: v1(45.125,48.725) 45.55,49.15 48.712,49.15 49.687,48.175 53.675,48.175 55.796,50.296 U10D.D3@55.796,51.684
DDR3_DQ0: U10F.C2 U11D.E3 | length 16.9
  L1 w0.1: U10F.C2@48.728,39.707 49.432,39.707 51.975,42.25 54,42.25 56.125,44.375 56.125,45.225 55.475,45.875 55.475,47.45 56.037,48.012 56.138,48.012 58.112,49.987 U11D.E3@58.624,49.987
DDR3_DQ1: U10F.F1 U11D.F7 | length 22
  L1 w0.1: U10F.F1@47.314,42.536 47.703,42.925 49.2,42.925 50.163,43.887 50.275,44 50.275,44.144 50.065,44.353 50.065,44.497 50.21,44.642 50.354,44.642 50.635,44.36 50.917,44.079 51.061,44.079 51.205,44.223 51.205,44.367 50.924,44.649 50.642,44.93 50.642,45.074 50.787,45.219 50.931,45.219 51.212,44.937 51.494,44.656 51.638,44.656 51.782,44.8 51.782,44.944 51.501,45.226 51.219,45.507 51.219,45.651 51.364,45.796 51.508,45.796 51.789,45.514 52.071,45.233 52.215,45.233 52.359,45.377 52.359,45.521 52.078,45.803 52.019,45.862 52.019,46.006 52.163,46.15 52.307,46.15 52.366,46.091 52.648,45.81 52.792,45.81 52.936,45.954 52.936,46.098 52.727,46.308 52.727,46.452 52.943,46.668 53.088,46.812 56.225,49.95 56.225,50.55 57.55,51.875 57.55,52.255 56.99,52.816 U11D.F7@56.927,52.816 U11D.F7@56.925,52.813
DDR3_DQ2: U10F.B1 U11D.F2 | length 16.3
  L1 w0.1: U10F.B1@50.142,39.707 52.335,41.9 54.5,41.9 60.675,48.075 60.675,48.502 59.756,49.421 U11D.F2@59.756,49.987
DDR3_DQ3: U10F.F3 U11D.F8 | length 22.4
  L1 w0.1: U10F.F3@45.899,41.121 46.596,41.121 47.075,41.6 47.075,42.075 46.8,42.35 46.8,42.725 47.15,43.075 47.475,43.075 47.6,43.2 48.275,43.2 48.8,43.725 48.8,44.4 48.913,44.512 49.105,44.705 49.105,44.849 48.895,45.058 48.895,45.202 49.04,45.347 49.184,45.347 49.465,45.065 49.747,44.784 49.891,44.784 50.035,44.928 50.035,45.072 49.754,45.354 49.472,45.635 49.472,45.779 49.617,45.924 49.761,45.924 50.042,45.642 50.324,45.361 50.468,45.361 50.612,45.505 50.612,45.649 50.403,45.859 50.403,46.003 50.475,46.075 50.75,46.35 52.3,46.35 55.9,49.95 55.9,50.65 56.725,51.475 56.725,52.45 56.362,52.813 U11D.F8@56.362,53.381
DDR3_DQ4: U10F.A1 U11D.H3 | length 20.2
  L1 w0.1: U10F.A1@50.849,39 53.024,41.175 56.525,41.175 61.95,46.6 61.95,47.225 61.525,47.65 61.525,47.9 61.8,48.175 61.8,49.654 60.321,51.133 U11D.H3@60.321,51.684
DDR3_DQ5: U10F.D2 U11D.H8 | length 21.7
  L1 w0.1: U10F.D2@48.021,40.414 47.75,40.685 47.75,41.404 47.621,41.534 47.621,41.994 47.855,42.228 49.928,42.228 50.912,43.212 52.637,43.212 53.875,44.45 53.875,46.925 56.75,49.8 56.75,50.375 57.987,51.612 57.987,52.038 58.35,52.4 58.35,53.743 58.409,53.802 58.409,54.141 58.037,54.513 U11D.H8@57.493,54.513
DDR3_DQ6: U10F.B2 U11D.G2 | length 20.1
  L1 w0.1: U10F.B2@49.435,39 50.1,39 52.625,41.525 56.425,41.525 61.35,46.45 61.35,46.7 60.65,47.4 60.65,47.725 61.284,48.359 61.284,49.025 60.321,49.987 U11D.G2@60.321,50.553
DDR3_DQ7: U10F.E2 U11D.H7 | length 19.4
  L1 w0.1: U10F.E2@47.314,41.121 47.314,41.97 47.772,42.428 49.74,42.428 50.843,43.532 52.357,43.532 53.45,44.625 53.45,46.825 56.487,49.862 56.487,50.463 57.775,51.75 57.775,52.15 58.116,52.491 58.116,52.975 58.059,53.032 U11D.H7@58.059,53.947
DDR3_DQ8: U10F.J5 U11D.D7 | length 20.6
  L1 w0.1: U10F.J5@42.364,41.828 v1(42.364,42.528) ; v2(55.227,51.684) U11D.D7@55.796,51.684
  L3 w0.1: v1(42.364,42.528) 42.364,43.214 46.65,47.5 49.9,47.5 50.287,47.887 50.395,47.995 50.61,47.995 50.678,47.927 50.893,47.927 51.108,48.142 51.108,48.357 50.932,48.532 50.757,48.708 50.757,48.923 50.972,49.138 51.187,49.138 51.362,48.962 51.538,48.787 51.753,48.787 51.968,49.002 51.968,49.217 51.792,49.392 51.617,49.568 51.617,49.783 51.832,49.998 52.047,49.998 52.115,49.93 52.33,49.93 52.625,50.225 54.084,51.684 v2(55.227,51.684)
DDR3_DQ9: U10F.H3 U11D.C3 | length 18.9
  L1 w0.1: U10F.H3@44.485,42.536 44.502,42.519 v1(44.502,41.827) ; U11D.C3@57.493,48.856 v2(58.062,48.856)
  L3 w0.1: v1(44.502,41.827) 44.502,43.693 44.485,43.71 46.95,46.175 51.45,46.175 54.131,48.856 v2(58.062,48.856)
DDR3_DQ10: U10F.K1 U11D.C8 | length 16.2
  L1 w0.1: U10F.K1@44.485,45.364 47.496,48.375 47.496,50.646 51.025,54.175 51.608,54.175 54.099,51.684 U11D.C8@54.665,51.684
DDR3_DQ11: U10F.H2 U11D.C2 | length 17.4
  L1 w0.1: v1(45.192,42.543) U10F.H2@45.192,43.243 ; v2(58.059,47.721) U11D.C2@58.059,48.29
  L3 w0.1: v1(45.192,42.543) 45.192,43.817 47.075,45.7 51.9,45.7 54,47.8 56.125,47.8 56.625,47.3 57.637,47.3 v2(58.059,47.721)
DDR3_DQ12: U10F.J1 U11D.A7 | length 17.3
  L1 w0.1: U10F.J1@45.192,44.657 48.111,47.575 48.111,49.911 48.775,50.575 49.45,50.575 50.125,49.9 50.125,49.35 49.25,48.475 49.25,48.05 49.725,47.575 51.687,47.575 U11D.A7@54.099,49.987
DDR3_DQ13: U10F.G2 U11D.A2 | length 13.7
  L1 w0.1: U10F.G2@45.899,42.536 v1(45.899,43.235) ; v2(55.884,46.116) 55.884,46.684 56.359,47.159 U11D.A2@56.927,47.159
  L3 w0.1: v1(45.899,43.235) 46.31,43.235 47.9,44.825 52.25,44.825 53.541,46.116 v2(55.884,46.116)
DDR3_DQ14: U10F.H5 U11D.B8 | length 20.2
  L1 w0.1: v1(43.071,40.422) U10F.H5@43.071,41.121 ; v2(52.625,49.1) 52.625,50.2 53.544,51.119 U11D.B8@54.099,51.119
  L3 w0.1: v1(43.071,40.422) 43.071,41.196 43.2,41.325 43.85,41.325 44,41.475 44,41.9 43.825,42.075 43.5,42.075 43.275,42.3 43.05,42.3 42.95,42.4 42.95,42.575 43.075,42.7 43.275,42.7 43.5,42.925 43.5,43.725 46.825,47.05 50.575,47.05 v2(52.625,49.1)
DDR3_DQ15: U10F.G3 U11D.A3 | length 15.9
  L1 w0.1: v1(45.192,41.129) U10F.G3@45.192,41.828 ; v2(55.894,47.256) U11D.A3@56.362,47.724
  L3 w0.1: v1(45.192,41.129) 45.192,41.792 45.625,42.225 45.625,42.825 45.499,42.951 45.499,43.401 45.734,43.635 46.31,43.635 47.9,45.225 52.05,45.225 54.081,47.256 v2(55.894,47.256)
DDR3_DQ16: U10D.E3 U10F.N2 | length 21.3
  L1 w0.1: U10F.N2@41.657,46.778 v1(41.657,47.478)
  L4 w0.1: v1(41.657,47.478) 42.778,47.478 43.325,48.025 52.075,48.025 52.3,48.25 52.3,48.675 52.125,48.85 51.65,48.85 51.575,48.925 51.575,49.375 51.775,49.575 53.675,49.575 53.875,49.775 53.875,50.1 53.275,50.7 53.275,51.05 53.5,51.275 55.4,51.275 55.793,51.668 v2(55.793,52.25)
  L6 w0.1: v2(55.793,52.25) U10D.E3@56.362,52.25
DDR3_DQ17: U10D.F7 U10F.M6 | length 27.5
  L1 w0.1: U10F.M6@39.536,43.243 v1(39.536,43.942)
  L4 w0.1: v1(39.536,43.942) 39.753,43.725 40.45,43.725 40.675,43.5 41.25,43.5 41.4,43.65 41.4,44.075 42,44.675 44.775,44.675 45.5,45.4 46.725,45.4 47.275,44.85 47.3,44.85 47.323,44.85 47.779,44.85 47.931,44.698 47.931,44.602 48.083,44.45 48.387,44.45 48.539,44.602 48.539,44.85 48.539,45.198 48.691,45.35 48.995,45.35 49.147,45.198 49.147,44.85 49.147,44.602 49.299,44.45 49.603,44.45 49.755,44.602 49.755,44.85 49.755,45.198 49.907,45.35 50.211,45.35 50.363,45.198 50.363,44.85 50.363,44.602 50.515,44.45 50.819,44.45 50.971,44.602 50.971,44.698 51.123,44.85 51.275,44.85 51.425,44.85 57.128,50.553 v2(58.621,50.553)
  L6 w0.1: v2(58.621,50.553) U10D.F7@59.19,50.553
DDR3_DQ18: U10D.F2 U10F.P1 | length 19.9
  L1 w0.1: U10F.P1@41.657,48.192 v1(41.657,48.892)
  L6 w0.1: v1(41.657,48.892) 43.55,50.785 47.685,50.785 53.05,56.15 54.175,56.15 55.469,54.856 55.469,54.839 55.959,54.35 55.975,54.35 56.362,53.963 U10D.F2@56.362,53.381
DDR3_DQ19: U10D.F8 U10F.N5 | length 25.3
  L1 w0.1: v1(38.836,44.657) U10F.N5@39.536,44.657
  L4 w0.1: v1(38.836,44.657) 39.493,44.657 39.975,44.175 40.6,44.175 40.767,44.342 41.242,44.342 41.85,44.95 44.6,44.95 45.315,45.665 51.865,45.665 57.128,50.928 59.384,50.928 v2(59.756,50.556)
  L6 w0.1: U10D.F8@59.756,49.987 v2(59.756,50.556)
DDR3_DQ20: U10D.H3 U10F.P2 | length 23.9
  L1 w0.1: v1(40.95,46.786) U10F.P2@40.95,47.485
  L4 w0.1: v1(40.95,46.786) 40.95,47.55 41.325,47.925 41.925,47.925 42.075,47.775 42.675,47.775 43.2,48.3 50.1,48.3 55.65,53.85 56.45,53.85 v2(56.925,53.375)
  L6 w0.1: v2(56.925,53.375) 57.366,52.934 57.366,52.51 57.585,52.291 57.916,52.291 58.175,52.55 58.175,52.95 58.059,53.066 U10D.H3@58.059,53.947
DDR3_DQ21: U10D.H8 U10F.N4 | length 25.5
  L1 w0.1: v1(39.543,45.364) U10F.N4@40.243,45.364
  L4 w0.1: v1(39.543,45.364) 40.093,45.364 40.707,44.75 41.325,44.75 41.8,45.225 44.45,45.225 45.191,45.966 51.741,45.966 56.95,51.175 59.075,51.175 v2(59.675,51.775)
  L6 w0.1: v2(59.675,51.775) 60.331,51.119 U10D.H8@60.887,51.119
DDR3_DQ22: U10D.G2 U10F.R1 | length 21.1
  L1 w0.1: U10F.R1@40.95,48.899 v1(40.95,49.599)
  L6 w0.1: v1(40.95,49.599) 41.924,49.599 43.375,51.05 47.475,51.05 53.1,56.675 54.765,56.675 56.927,54.513 U10D.G2@56.927,53.947
DDR3_DQ23: U10D.H7 U10F.P6 | length 26.6
  L1 w0.1: U10F.P6@38.121,44.657 v1(38.121,45.357)
  L4 w0.1: v1(38.121,45.357) 38.807,45.357 39.214,45.764 39.976,45.764 40.769,44.971 41.115,44.971 41.619,45.475 44.15,45.475 44.906,46.231 51.631,46.231 57.084,51.684 58.259,51.684 v2(58.7,52.125)
  L6 w0.1: v2(58.7,52.125) 59.1,52.125 59.225,52.25 59.756,52.25 U10D.H7@60.321,51.684
DDR3_DQ24: U10D.D7 U10F.K3 | length 18.9
  L1 w0.1: U10F.K3@43.071,43.95 43.071,44.515 44.32,45.764 44.439,45.764 46.575,47.9 v1@46.575,48.6
  L6 w0.1: v1(46.575,48.725) 48.762,48.725 49.587,47.9 53.775,47.9 55.6,49.725 57.755,49.725 U10D.D7@58.059,49.421
DDR3_DQ25: U10D.C3 U10F.M2 | length 20.7
  L1 w0.1: U10F.M2@42.364,46.071 42.364,46.637 43.975,48.248 43.975,49.4 43.525,49.85 43.525,50.4 43.8,50.675 44.25,50.675 44.45,50.475 v1(44.45,49.125)
  L6 w0.1: v1(44.45,49.125) 44.8,49.475 48.95,49.475 50,48.425 53.525,48.425 55.23,50.13 U10D.C3@55.23,51.119
DDR3_DQ26: U10D.C8 U10F.K4 | length 18.2
  L1 w0.1: U10F.K4@42.364,43.243 v1(42.364,43.942)
  L4 w0.1: v1(42.364,43.942) 51.892,43.942 56.24,48.29 v2(57.49,48.29)
  L6 w0.1: v2(57.49,48.29) U10D.C8@58.059,48.29
DDR3_DQ27: U10D.C2 U10F.M3 | length 20.3
  L1 w0.1: U10F.M3@41.657,45.364 41.657,46.032 42.164,46.539 42.164,46.72 43.135,47.69 43.135,48.365 42.65,48.85 42.65,49.275 42.8,49.425 43.075,49.425 v1(43.55,48.95)
  L6 w0.1: v1(43.55,48.95) 44.325,49.725 49.85,49.725 50.9,48.675 53.3,48.675 55.025,50.4 55.025,50.75 54.665,51.11 U10D.C2@54.665,51.684
DDR3_DQ28: U10D.A7 U10F.J6 | length 23.4
  L1 w0.1: U10F.J6@41.657,41.121 v1(41.657,41.821)
  L6 w0.1: v1(41.657,41.821) 41.657,42.432 42.875,43.65 42.875,44.225 41.925,45.175 41.925,45.7 42.175,45.95 42.575,45.95 43.025,45.5 43.025,45.1 43.3,44.825 44.275,44.825 44.425,44.975 44.425,45.925 44.625,46.125 44.925,46.125 45.175,45.875 45.175,45.45 45.35,45.275 45.575,45.275 46.175,45.875 53.575,45.875 55.424,47.724 U10D.A7@56.362,47.724
DDR3_DQ29: U10D.A2 U10F.L5 | length 21.5
  L1 w0.1: U10F.L5@40.95,43.243 v1(40.95,43.942)
  L6 w0.1: v1(40.95,43.942) 41.352,44.345 41.352,47.098 40.875,47.575 40.875,48.075 41.2,48.4 41.875,48.4 43.775,50.3 49.125,50.3 49.4,50.575 49.4,51.1 49.663,51.363 49.663,52.063 50,52.4 50.375,52.4 50.6,52.175 50.6,51.625 51.672,50.553 U10D.A2@53.533,50.553
DDR3_DQ30: U10D.B8 U10F.J4 | length 18.5
  L1 w0.1: v1(43.071,41.836) U10F.J4@43.071,42.536
  L6 w0.1: v1(43.071,41.836) 43.071,42.421 46.207,45.557 53.707,45.557 53.875,45.725 56.5,45.725 56.975,46.2 56.975,46.65 57.493,47.168 U10D.B8@57.493,47.724
DDR3_DQ31: U10D.A3 U10F.K6 | length 19.9
  L1 w0.1: U10F.K6@40.95,41.828 v1(40.95,42.528)
  L6 w0.1: v1(40.95,42.528) 40.95,43.225 41.675,43.95 41.675,46.289 42.825,47.439 42.825,48.85 43.962,49.987 51.325,49.987 51.762,49.55 53.662,49.55 U10D.A3@54.099,49.987
DDR3_DQS0_N: U10F.D1 U11D.G3 | length 20.4
  L1 w0.1: U10F.D1@48.728,41.121 48.728,41.197 48.525,41.4 48.325,41.4 48.2,41.275 48.2,41.1 48.575,40.725 48.892,40.725 51.017,42.85 53.8,42.85 55.275,44.325 55.275,44.917 54.225,45.967 54.225,46.858 57.6,50.233 57.6,50.858 57.992,51.25 59.2,51.25 59.331,51.119 U11D.G3@59.756,51.119
DDR3_DQS0_P: U10F.E1 U11D.F3 | length 20.4
  L1 w0.1: U10F.E1@48.021,41.828 48.021,41.758 48,41.737 48,41.017 48.492,40.525 48.975,40.525 51.1,42.65 53.883,42.65 55.5,44.267 55.5,44.975 54.425,46.05 54.425,46.775 57.8,50.15 57.8,50.775 58.075,51.05 59.117,51.05 59.19,50.977 U11D.F3@59.19,50.553
DDR3_DQS1_N: U10F.J2 U11D.B7 | length 16.3
  L1 w0.1: U10F.J2@44.485,43.95 44.485,44.365 44.4,44.45 44.175,44.45 43.925,44.2 43.925,43.944 44.319,43.55 44.651,43.55 48.301,47.2 52.075,47.2 55.196,50.321 55.196,50.446 55.089,50.553 U11D.B7@54.665,50.553
DDR3_DQS1_P: U10F.K2 U11D.C7 | length 16.5
  L1 w0.1: U10F.K2@43.778,44.657 43.778,44.586 43.725,44.533 43.725,43.861 44.236,43.35 44.734,43.35 48.384,47 52.158,47 55.396,50.238 55.396,50.529 55.23,50.694 U11D.C7@55.23,51.119
DDR3_DQS2_N: U10D.G3 U10F.P4 | length 24.5
  L1 w0.1: U10F.P4@39.536,46.071 v1(39.536,46.771)
  L4 w0.1: v1(39.536,46.771) 39.431,46.875 39.2,46.875 39.075,46.75 39.075,46.483 39.383,46.175 42.117,46.175 43.592,47.65 52.175,47.65 56.3,51.775 56.3,52.658 56.479,52.837 57.145,52.837 57.316,52.666 v2(57.741,52.666)
  L6 w0.1: U10D.G3@57.493,53.381 57.741,53.134 v2(57.741,52.666)
DDR3_DQS2_P: U10D.F3 U10F.P5 | length 23.7
  L1 w0.1: U10F.P5@38.828,45.364 v1(38.828,46.064)
  L4 w0.1: v1(38.828,46.064) 38.89,46.125 39.15,46.125 39.3,45.975 42.2,45.975 43.675,47.45 52.258,47.45 56.5,51.692 56.5,52.575 56.562,52.637 57.062,52.637 57.175,52.524 v2(57.175,52.1)
  L6 w0.1: U10D.F3@56.927,52.816 57.166,52.577 57.166,52.109 v2(57.175,52.1)
DDR3_DQS3_N: U10D.B7 U10F.L1 | length 19.4
  L1 w0.1: U10F.L1@43.896,46.071 U10F.L1@43.778,46.071 43.778,46.428 43.875,46.525 v1(44.35,46.525)
  L6 w0.1: v1(44.35,46.525) 44.55,46.725 44.55,46.85 44.35,47.05 44.35,47.2 44.684,47.534 45.116,47.534 45.875,46.775 46.418,46.775 46.679,47.036 46.679,47.132 46.822,47.275 47.144,47.275 47.287,47.132 47.287,46.536 47.548,46.275 48.034,46.275 48.295,46.536 48.295,47.132 48.438,47.275 48.76,47.275 48.903,47.132 48.903,46.536 49.164,46.275 49.65,46.275 49.911,46.536 49.911,46.632 50.054,46.775 53.775,46.775 55.908,48.908 56.733,48.908 56.817,48.825 57,48.825 57.1,48.725 57.1,48.463 U10D.B7@56.927,48.29
DDR3_DQS3_P: U10D.C7 U10F.M1 | length 18.9
  L1 w0.1: U10F.M1@43.071,46.778 43.318,47.025 v1(43.9,47.025)
  L6 w0.1: v1(43.9,47.025) 43.9,47.033 44.209,47.341 44.601,47.734 45.199,47.734 45.958,46.975 46.336,46.975 46.479,47.118 46.479,47.214 46.74,47.475 47.226,47.475 47.487,47.214 47.487,46.618 47.63,46.475 47.952,46.475 48.095,46.618 48.095,47.214 48.356,47.475 48.842,47.475 49.103,47.214 49.103,46.618 49.246,46.475 49.568,46.475 49.711,46.618 49.711,46.714 49.972,46.975 53.692,46.975 55.825,49.108 56.816,49.108 56.9,49.025 57.324,49.025 U10D.C7@57.493,48.856
DDR3_ODT0: RP11D.7 U10D.K1 U10F.W9 U11D.K1 | length 60.5
  L1 w0.1: U10F.W9@32.464,46.071 v1(32.464,46.771) ; v2(60.039,53.665) 60.039,53.437 60.668,52.808 60.88,52.808 62.004,51.684 U11D.K1@62.584,51.684 ; v1(63.425,48) 64.85,48 65,47.85 65.853,47.85 RP11D.7@65.978,47.724
  L3 w0.1: v1(32.464,46.771) 32.464,46.22 35.155,43.53 35.53,43.53 35.925,43.925 36.075,43.925 36.625,43.375 36.825,43.375 42.475,49.025 42.825,49.025 43.675,48.175 45.5,48.175 45.825,48.5 45.825,49.15 46.325,49.65 47.025,49.65 47.175,49.8 47.247,49.872 47.247,50.016 47.179,50.084 47.179,50.229 47.323,50.373 47.468,50.373 47.608,50.233 47.748,50.093 47.892,50.093 48.036,50.237 48.036,50.381 47.896,50.521 47.756,50.661 47.756,50.806 47.9,50.95 48.045,50.95 48.185,50.81 48.325,50.67 48.469,50.67 48.613,50.814 48.613,50.958 48.473,51.098 48.333,51.238 48.333,51.383 48.477,51.527 48.622,51.527 48.762,51.387 48.902,51.247 49.046,51.247 49.19,51.391 49.19,51.535 49.05,51.675 48.91,51.815 48.91,51.96 49.054,52.104 49.199,52.104 49.339,51.964 49.479,51.824 49.623,51.824 49.767,51.968 49.767,52.112 49.627,52.252 49.487,52.392 49.487,52.537 49.631,52.681 49.776,52.681 49.916,52.541 50.056,52.401 50.2,52.401 50.344,52.545 50.344,52.689 50.204,52.829 50.064,52.969 50.064,53.114 50.208,53.258 50.353,53.258 50.493,53.118 50.633,52.978 50.777,52.978 50.921,53.122 50.921,53.266 50.781,53.406 50.641,53.546 50.641,53.691 50.785,53.835 50.93,53.835 51.07,53.695 51.21,53.555 51.354,53.555 51.498,53.699 51.498,53.843 51.43,53.911 51.43,54.055 51.613,54.237 51.75,54.375 52.05,54.375 52.375,54.05 52.9,54.05 53.175,53.775 53.825,53.775 54.425,54.375 55,54.375 55.525,53.85 57.025,53.85 57.35,53.525 58.125,53.525 58.779,54.179 59.525,54.179 v2(60.039,53.665)
  L4 w0.1: v2(60.039,53.665) 63.425,50.279 v1(63.425,48)
  L6 w0.1: U10D.K1@58.151,56.118 58.151,55.517 58.434,55.233 58.668,55.233 58.759,55.142 58.759,54.945 v2(60.039,53.665)
DDR3_RAS_N: RP11D.8 U10D.J3 U10F.Y9 U11D.J3 | length 60.6
  L1 w0.1: U10F.Y9@31.757,46.778 v1(31.757,47.478) ; v2(59.375,53.763) U11D.J3@60.887,52.25 U11D.J3@60.887,52.25 ; v1(63.525,47.25) 64.3,47.25 64.375,47.175 65.429,47.175 RP11D.8@65.528,47.274
  L3 w0.1: v1(31.757,47.478) 31.757,46.825 31.225,46.293 31.225,45.95 32.425,44.75 32.575,44.75 33,45.175 33.227,45.175 35.752,42.65 36.075,42.65 36.55,43.125 36.775,43.125 37.25,42.65 37.5,42.65 42.75,47.9 46.6,47.9 47.112,48.412 47.185,48.485 47.185,48.629 47.117,48.697 47.117,48.841 47.261,48.985 47.405,48.985 47.545,48.845 47.685,48.705 47.83,48.705 47.974,48.849 47.974,48.994 47.834,49.134 47.694,49.274 47.694,49.418 47.838,49.562 47.982,49.562 48.122,49.422 48.262,49.282 48.407,49.282 48.551,49.426 48.551,49.571 48.411,49.711 48.271,49.851 48.271,49.995 48.415,50.139 48.559,50.139 48.699,49.999 48.839,49.859 48.984,49.859 49.128,50.003 49.128,50.148 48.988,50.288 48.848,50.428 48.848,50.572 48.992,50.716 49.136,50.716 49.276,50.576 49.416,50.436 49.561,50.436 49.705,50.58 49.705,50.725 49.565,50.865 49.425,51.005 49.425,51.149 49.569,51.293 49.713,51.293 49.853,51.153 49.993,51.013 50.138,51.013 50.282,51.157 50.282,51.302 50.142,51.442 50.002,51.582 50.002,51.726 50.146,51.87 50.29,51.87 50.43,51.73 50.57,51.59 50.715,51.59 50.859,51.734 50.859,51.879 50.719,52.019 50.579,52.159 50.579,52.303 50.723,52.447 50.867,52.447 51.007,52.307 51.147,52.167 51.292,52.167 51.436,52.311 51.436,52.456 51.296,52.596 51.156,52.736 51.156,52.88 51.3,53.024 51.444,53.024 51.512,52.956 51.656,52.956 51.873,53.173 51.9,53.2 52.002,53.2 52.104,53.302 52.104,53.398 52.206,53.5 52.41,53.5 52.512,53.398 52.512,53.2 52.512,53.002 52.614,52.9 52.818,52.9 52.92,53.002 52.92,53.098 53.022,53.2 53.275,53.2 53.734,53.2 54.084,52.85 54.65,52.85 54.962,53.162 55.388,53.162 55.75,52.8 57.15,52.8 57.425,53.075 58.389,53.075 59.077,53.763 v2(59.375,53.763)
  L4 w0.1: v2(59.375,53.763) 62.95,50.188 62.95,47.825 v1(63.525,47.25)
  L6 w0.1: U10D.J3@58.624,54.513 58.476,54.364 58.476,54.152 58.589,54.039 58.589,53.897 58.462,53.77 58.462,53.629 58.773,53.318 58.914,53.318 59.226,53.629 59.36,53.763 v2(59.375,53.763)
DDR3_RESET_N: R11D.2 U10D.T2 U10F.AB5 U11D.T2 | length 50.3
  L1 w0.1: U10F.AB5@33.172,51.021 v1(33.172,51.721) ; U11D.T2@65.413,55.644 66.084,56.316 66.084,58.055 66.325,58.296 66.325,58.552 v2(65.625,59.251) 65.724,59.251 R11D.2@66.849,60.376
  L3 w0.1: v1(33.172,51.721) 33.172,53.497 35.775,56.1 37.25,56.1 41.875,60.725 57.2,60.725 59,62.525 62.351,62.525 v2(65.625,59.251)
  L6 w0.1: U10D.T2@62.018,59.038 62.479,59.498 64.141,59.498 64.59,59.947 64.929,59.947 v2(65.625,59.251)
DDR3_WE_N: RP11D.5 U10D.L3 U10F.V8 U11D.L3 | length 58.7
  L1 w0.1: U10F.V8@33.879,46.071 v1(33.879,46.771) ; v2(60.57,55.256) 61.197,54.629 61.197,54.063 61.878,53.381 U11D.L3@62.018,53.381 ; v1(66.261,49.05) RP11D.5@66.783,48.529
  L3 w0.1: v1(33.879,46.771) 34.579,46.771 35.05,46.3 35.671,46.3 37.648,48.277 37.675,48.277 39.136,49.738 39.136,49.766 39.37,50 ; 39.371,50 39.471,50.1 40.17,50.1 40.87,50.8 43.825,50.8 44.025,51 44.097,51.072 44.241,51.072 44.309,51.004 44.454,51.004 44.598,51.148 44.598,51.293 44.458,51.433 44.318,51.573 44.318,51.717 44.462,51.861 44.606,51.861 44.746,51.721 44.886,51.581 45.031,51.581 45.175,51.725 45.175,51.87 45.035,52.01 44.895,52.15 44.895,52.294 45.039,52.438 45.183,52.438 45.323,52.298 45.463,52.158 45.608,52.158 45.752,52.302 45.752,52.447 45.612,52.587 45.472,52.727 45.472,52.871 45.616,53.015 45.76,53.015 45.9,52.875 46.04,52.735 46.185,52.735 46.329,52.879 46.329,53.024 46.189,53.164 46.049,53.304 46.049,53.448 46.193,53.592 46.337,53.592 46.477,53.452 46.617,53.312 46.762,53.312 46.906,53.456 46.906,53.601 46.766,53.741 46.626,53.881 46.626,54.025 46.77,54.169 46.914,54.169 47.054,54.029 47.194,53.889 47.339,53.889 47.483,54.033 47.483,54.178 47.343,54.318 47.203,54.458 47.203,54.602 47.347,54.746 47.491,54.746 47.631,54.606 47.771,54.466 47.916,54.466 48.06,54.61 48.06,54.755 47.92,54.895 47.78,55.035 47.78,55.179 47.924,55.323 48.068,55.323 48.208,55.183 48.348,55.043 48.493,55.043 48.637,55.187 48.637,55.332 48.497,55.472 48.357,55.612 48.357,55.756 48.501,55.9 48.645,55.9 48.785,55.76 48.925,55.62 49.07,55.62 49.214,55.764 49.214,55.909 49.146,55.977 49.146,56.121 49.362,56.337 49.425,56.4 49.527,56.4 49.629,56.298 49.629,56.202 49.731,56.1 49.935,56.1 50.037,56.202 50.037,56.4 50.037,56.523 50.139,56.625 50.343,56.625 50.445,56.523 50.445,56.4 50.445,56.302 50.547,56.2 50.751,56.2 50.853,56.302 50.853,56.4 50.853,56.523 50.955,56.625 51.159,56.625 51.261,56.523 51.261,56.4 51.261,56.302 51.363,56.2 51.567,56.2 51.669,56.302 51.669,56.4 51.669,56.523 51.771,56.625 51.975,56.625 52.077,56.523 52.077,56.4 52.077,56.302 52.179,56.2 52.383,56.2 52.485,56.302 52.485,56.4 52.485,56.523 52.587,56.625 52.791,56.625 52.893,56.523 52.893,56.4 52.893,56.302 52.995,56.2 53.199,56.2 53.301,56.302 53.301,56.4 53.301,56.523 53.403,56.625 53.607,56.625 53.709,56.523 53.709,56.4 53.709,56.302 53.811,56.2 54.015,56.2 54.117,56.302 54.215,56.4 54.3,56.4 56.8,56.4 57.375,55.825 60,55.825 v2(60.57,55.256) 61.225,54.6 61.225,54.05 61.75,53.525 62.275,53.525 63.075,52.725 63.075,51.85 65.6,49.325 65.986,49.325 v1(66.261,49.05)
  L6 w0.1: U10D.L3@59.756,55.644 59.579,55.821 59.579,56.265 59.686,56.372 59.821,56.372 59.914,56.279 59.915,56.055 60.166,55.804 60.166,55.404 60.314,55.256 v2(60.57,55.256)
EZPCS_NMI: R16C.2 U11C.26 | length 6.7
  L1 w0.1: U11C.26@71.3,42.775 71.3,44.175 70.525,44.95 70.525,47.1 71.4,47.975 R16C.2@72.225,47.975
FB_P1.0V: R14P.1 R16P.1 U10P.A3 | length 2.6
  L1 w0.15: R16P.1@57.05,31.775 R14P.1@57.05,32.975 57.4,33.325 U10P.A3@57.4,34.275
FB_P1.5V: R23P.1 R25P.1 U12P.A3 | length 2.6
  L1 w0.15: U12P.A3@70.375,66.95 71.325,66.95 71.675,66.6 R25P.1@72.875,66.6
FB_P1.8V: R15P.1 R17P.1 U11P.A3 | length 2.6
  L1 w0.15: R17P.1@38.75,20.025 39.95,20.025 40.3,19.675 U11P.A3@41.25,19.675
FB_P3.3V: R24P.1 R26P.1 U13P.A3 | length 2.6
  L1 w0.15: U13P.A3@85.875,67.375 86.825,67.375 R24P.1@87.175,67.025 R26P.1@88.375,67.025
FB_P5.0V: C39P.2 R30P.1 R31P.2 U16P.4 | length 4.5
  L1 w0.2: R31P.2@15.7,79.125 R30P.1@17.025,79.125 ; U16P.4@16.67,77.25 16.67,78.095 17.025,78.45 R30P.1@17.025,79.125 ; C39P.2@17.025,80.275 R30P.1@17.025,79.125
FPGA_DONE: R14F.1 U10F.G11 U11C.36 | length 38.5
  L1 w0.1: v1@38.836,36.172 U10F.G11@39.536,36.172 ; U11C.36@66.5,39.475 v1(68.15,39.475)
  L4 w0.1: v1(38.828,36.164) 39.539,36.164 40.125,36.75 43.2,36.75 43.85,36.1 45.1,36.1 45.75,36.75 47.55,36.75 48.7,35.6 49.6,35.6 52.775,38.775 58.2,38.775 59.275,39.85 65.75,39.85 66.125,39.475 v1(68.15,39.475)
  L6 w0.1: R14F.1@35.549,35.926 37.049,35.926 37.4,35.575 37.65,35.575 38.239,36.164 v1(38.828,36.164)
FPGA_INIT: R13F.1 U10F.U12 U11C.41 | length 53.9
  L1 w0.1: U10F.U12@31.757,42.536 v1(31.757,43.235) ; U11C.41@66.5,36.975 v1(68.15,36.975)
  L4 w0.1: v1(31.757,43.235) 32.022,43.5 32.75,43.5 33.05,43.8 34.725,43.8 39.675,38.85 42.2,38.85 43.5,40.15 44,40.15 44.225,39.925 44.725,39.925 44.975,40.175 45.4,40.175 45.65,39.925 46.125,39.925 46.35,40.15 46.85,40.15 47.05,39.95 47.5,39.95 47.75,40.2 48.425,40.2 48.975,39.65 52.75,39.65 53.275,40.175 67.425,40.175 67.625,39.975 68.85,39.975 69.35,39.475 69.35,36.575 68.875,36.1 68.875,35.85 68.5,35.475 67.75,35.475 67.5,35.725 67.5,36.325 v1(68.15,36.975)
  L6 w0.1: R13F.1@29.3,42.4 30.922,42.4 v1(31.757,43.235)
FPGA_LED0: R18F.2 U10F.M21 | length 51.4
  L1 w0.1: R18F.2@5.525,60.95 v1(6.525,60.95) ; v1(28.225,34.05) 28.929,33.346 U10F.M21@28.929,32.636
  L4 w0.1: v1(6.525,60.95) 13.8,53.675 13.8,50.35 16.925,47.225 16.925,33.3 19.55,30.675 23.825,30.675 24.6,29.9 25.2,29.9 25.95,30.65 27.5,30.65 29.075,32.225 29.075,33.2 v1(28.225,34.05)
FPGA_LED1: R17F.2 U10F.N20 | length 54.4
  L1 w0.1: R17F.2@5.45,65.45 v1(6.525,65.45) ; U10F.N20@28.929,34.05 v1(28.929,34.75)
  L4 w0.1: v1(6.525,65.45) 14.35,57.625 14.35,50.475 17.275,47.55 17.275,34.45 20.725,31 27.35,31 28.75,32.4 28.75,32.8 27.7,33.85 27.7,34.25 28.2,34.75 v1(28.929,34.75)
FPGA_LED2: R16F.2 U10F.L21 | length 32.1
  L1 w0.1: R16F.2@5.4,36.95 5.475,36.95 v1(6.3,37.775) ; U10F.L21@29.636,31.929 v1(30.336,31.929)
  L4 w0.1: v1(6.3,37.775) 13.175,37.775 16.6,34.35 16.6,33.15 19.425,30.325 23.75,30.325 24.45,29.625 26.725,29.625 27.5,28.85 28.075,28.85 28.95,29.725 28.95,30.543 v1(30.336,31.929)
FPGA_MODE: P10F.1 R15F.2 U10F.U9 U11C.35 | length 85.6
  L1 w0.1: U10F.U9@33.879,44.657 34.578,44.657 v1(34.586,44.665) ; v1(63.825,40.625) 64.475,39.975 U11C.35@66.5,39.975 74.925,39.975 79.95,45 v1(82.45,45)
  L3 w0.1: v1(82.45,45) 82.45,39.45 86.6,35.3 86.6,20.45 P10F.1@88.2,18.85
  L4 w0.1: v1(34.586,44.665) 35.285,44.665 40.725,39.225 41.125,39.225 42.825,40.925 44.65,40.925 44.9,40.675 45.45,40.675 45.8,41.025 48.45,41.025 49.213,40.262 51.412,40.262 51.775,40.625 v1(63.825,40.625)
  L6 w0.1: R15F.2@32.449,45.376 33.16,44.665 v1(34.586,44.665)
FPGA_PROGRAM_B: R12F.1 R24C.1 U10F.N12 U11C.42 | length 56.8
  L1 w0.1: v1(32.475,35.45) 34.375,37.35 34.375,37.8 34.075,38.1 34.075,38.5 34.586,39.011 U10F.N12@34.586,39.707 ; R24C.1@64.6,35.55 64.6,36.225 v1(64.85,36.475) U11C.42@66.5,36.475
  L3 w0.1: v1(64.85,36.475) 65.95,35.375 65.95,29.95 v1(65.25,29.25)
  L4 w0.1: v1(32.475,35.45) 32.475,34.7 39.5,27.675 50.775,27.675 52.15,26.3 64.3,26.3 65.25,27.25 v1(65.25,29.25)
  L6 w0.1: v1(32.475,35.45) 32.475,35.974 R12F.1@33.101,36.599
FPGA_PUDC: R10F.1 U10F.U22 | length 2.3
  L1 w0.1: v1(24.191,34.97) U10F.U22@24.686,35.464
  L6 w0.1: R10F.1@22.824,34.376 23.598,34.376 v1(24.191,34.97)
FPGA_SPI_CS: R10C.2 U10C.1 U10F.T19 | length 50.2
  L1 w0.1: U10C.1@26.405,69.3 26.405,71.045 26.45,71 v1(27.5,71) ; v1(26.815,36.879) U10F.T19@27.515,36.879
  L4 w0.1: v1(26.815,36.879) 23.296,36.879 20.525,39.65 20.525,44.199 25.425,49.099 25.425,58.2 25.65,58.425 25.65,59.875 21.525,64 21.525,66.85 23.55,68.875 26.2,68.875 27.5,70.175 v1(27.5,71)
FPGA_SPI_MISO_D1: U10C.2 U10F.R22 | length 50.9
  L1 w0.1: v1(24.725,33.45) 25.5,33.45 U10F.R22@26.101,34.05 ; U10C.2@25.135,69.3 v1(25.135,71.01)
  L4 w0.1: v1(24.725,33.45) 20.925,33.45 18.85,35.525 18.85,44.807 23.775,49.732 23.775,57.3 21.2,59.875 21.2,63.275 20.45,64.025 20.45,66.325 v1(25.135,71.01)
FPGA_SPI_MOSI_D0: U10C.5 U10F.P22 | length 38.8
  L1 w0.1: v1(21.95,60.975) 22.595,61.62 U10C.5@22.595,62.2 ; v1(25.939,32.475) U10F.P22@26.808,33.343
  L4 w0.1: v1(21.95,60.975) 21.95,60.275 24.2,58.025 24.2,49.65 19.25,44.7 19.25,36.375 21.575,34.05 24.725,34.05 25.939,32.836 v1(25.939,32.475)
FPGA_SPI_RES_D3: R11C.2 U10C.7 U10F.R21 | length 36.5
  L1 w0.1: v1(24.825,59.5) 25.135,59.81 U10C.7@25.135,62.2 ; v1(26.808,34.058) U10F.R21@26.808,34.757
  L4 w0.1: v1(24.825,59.5) 24.825,57.425 24.625,57.225 24.625,49.625 19.625,44.625 19.625,37.15 22.225,34.55 26.315,34.55 v1(26.808,34.058)
FPGA_SPI_SCK: U10C.6 U10F.L12 | length 46
  L1 w0.1: v1(23.865,60.71) U10C.6@23.865,62.2 ; v1(36,37.593) U10F.L12@36,38.293
  L4 w0.1: v1(23.865,60.71) 24.34,60.71 25.325,59.725 25.325,58.775 25.125,58.575 25.125,56.975 25.025,56.875 25.025,49.375 20.1,44.45 20.1,38.175 21.875,36.4 25.925,36.4 26.825,35.5 28.875,35.5 29.318,35.057 30.007,35.057 31.9,36.95 35.357,36.95 v1(36,37.593)
FPGA_SPI_WP_D2: R12C.2 U10C.3 U10F.P21 | length 56.9
  L1 w0.1: R12C.2@23.75,71.1 v1(23.75,72.175) ; U10C.3@23.865,69.3 R12C.2@23.865,71.035 ; v1(27.515,33.351) U10F.P21@27.515,34.05
  L4 w0.1: v1(23.75,72.175) 23.75,70.25 20.075,66.575 20.075,63.95 20.875,63.15 20.875,59.7 23.425,57.15 23.425,49.877 18.5,44.952 18.5,35.1 21.625,31.975 26.139,31.975 26.364,32.2 26.364,33.039 26.676,33.351 v1(27.515,33.351)
FPGA_TCK: P11C.8 U10F.V12 U11C.62 | length 68
  L1 w0.1: v1(30.35,44.65) 31.05,43.95 U10F.V12@31.05,43.243 ; P11C.8@69.01,27.77 69.01,28.735 69.725,29.45 73.85,29.45 74.8,30.4 U11C.62@74.8,31.675
  L4 w0.1: v1(30.35,44.65) 31.05,43.95 31.05,43.15 31.45,42.75 31.9,42.75 32.2,43.05 32.65,43.05 32.975,42.725 33.325,42.725 33.65,43.05 34.075,43.05 37.3,39.825 37.65,39.825 38.25,39.225 38.25,37.525 38.575,37.2 38.575,36.575 38.325,36.325 36.675,36.325 35.825,35.475 35.825,32.95 37.075,31.7 38.325,31.7 40.625,29.4 41.115,29.4 51.9,29.4 53.225,30.725 54.975,30.725 56,29.7 62.5,29.7 63.025,30.225 68.325,30.225 69.01,29.54 P11C.8@69.01,27.77
FPGA_TDI: P11C.14 U10F.R13 U11C.63 | length 59.7
  L1 w0.1: v1(31.765,40.414) U10F.R13@32.464,40.414 ; P11C.14@61.39,27.77 62.435,26.725 69.5,26.725 70.2,27.425 70.2,28.45 70.875,29.125 74.35,29.125 75.3,30.075 U11C.63@75.3,31.675
  L4 w0.1: v1(31.765,40.414) 32.436,40.414 34.075,38.775 35.55,38.775 36.55,37.775 36.55,37.45 35.025,35.925 35.025,32.475 37.3,30.2 38.5,30.2 40.225,28.475 50.425,28.475 52.25,26.65 60.27,26.65 P11C.14@61.39,27.77
FPGA_TDO: P11C.16 U10F.U13 U11C.64 | length 62.1
  L1 w0.1: v1(31.05,41.129) U10F.U13@31.05,41.828 ; P11C.16@58.85,27.77 60.17,26.45 69.825,26.45 70.55,27.175 70.55,28.35 71.05,28.85 74.95,28.85 75.8,29.7 U11C.64@75.8,31.675
  L4 w0.1: v1(31.05,41.129) 31.404,41.129 31.925,41.65 32.65,41.65 35.185,39.115 35.85,39.115 36.052,38.913 36.737,38.913 37.225,38.425 37.225,38.125 36.85,37.75 36.85,37.35 35.275,35.775 35.275,32.675 37.475,30.475 38.675,30.475 40.375,28.775 57.845,28.775 P11C.16@58.85,27.77
FPGA_TMS: P11C.12 U10F.T13 U11C.61 | length 63.8
  L1 w0.1: v1(30.35,43.25) 31.757,41.843 U10F.T13@31.757,41.121 ; P11C.12@63.93,27.77 64.945,27.77 67,29.825 73.625,29.825 74.3,30.5 U11C.61@74.3,31.675
  L4 w0.1: v1(30.35,43.25) 31.5,42.1 32.675,42.1 32.875,42.3 33.425,42.3 36.55,39.175 36.9,39.175 37.175,39.45 37.65,39.45 37.975,39.125 37.975,37.573 37.527,37.125 37.025,37.125 35.55,35.65 35.55,32.825 37.625,30.75 38.8,30.75 40.475,29.075 52.15,29.075 52.925,29.85 54,29.85 54.675,29.175 62.525,29.175 P11C.12@63.93,27.77
FUSB_N: R23H.2 R28H.1 U10F.C15 | length 76.1
  L1 w0.1: U10F.C15@39.536,30.515 v1(40.232,30.515) ; v1(75.1,67) 74.887,67.213 74.887,69.838 R28H.1@75.4,70.35 R23H.2@76.575,70.35
  L4 w0.1: v1(40.232,30.515) 40.798,30.515 41.027,30.285 42.284,30.285 43.049,31.05 43.55,31.05 43.9,30.7 46.433,30.7 47.908,32.175 52.375,32.175 52.625,31.925 61.108,31.925 62.158,32.975 67.883,32.975 70.375,35.467 70.375,41.967 80.125,51.717 80.125,61.158 74.9,66.383 v1@74.9,67
# Altium PCB netv2mvp-dvt1a.PCBDOC (part 1 of 6)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 90 x 100 mm, 6 copper layers (L1, L2, L3, L4, L5, L6), stack 1.542 mm thick; 329 components, 277 nets, 2092 pads, 848 vias.

## Layer stack, top to bottom
TopSolder: solder mask 0.0102, Solder Resist, Dk 3.5
L1: signal copper 0.045
Dielectric1: core 0.08, FR-4, Dk 4.3
L2: plane copper 0.0356, net GND
Dielectric4: prepreg 0.1, FR-4, Dk 4.3
L3: signal copper 0.0356
Dielectric2: core 0.95, FR-4, Dk 4.3
L4: signal copper 0.0356
Dielectric3: prepreg 0.1, FR-4, Dk 4.3
L5: plane copper 0.0356, net (Multiple Nets)
Dielectric5: core 0.08, FR-4, Dk 4.3
L6: signal copper 0.045
BottomSolder: solder mask 0.0102, Solder Resist, Dk 3.5

## Board outline
0,4.5 15,4.5 15,12.75 33.35,12.75 33.35,4.5 41.35,4.5 41.35,10.925 cw(c43.175,10.925) 45,10.925 45,0.5 45.5,0 55.7,0 56.2,0.5 56.2,7.45 cw(c57.15,7.45) 58.1,7.45 58.1,0.5 58.6,0 78.8,0 79.3,0.5 79.3,12.75 88.5,12.75 ccw(c88.5,14.25) 90,14.25 90,77.5 ccw(c88.5,77.5) 88.5,79 28.2,79 cw(c28.2,81.656) 26.322,79.778 25.398,80.702 cw(c27.566,82.87) 24.5,82.87 24.5,91.63 ccw(c21.434,91.63) 23.602,93.798 18.298,99.102 ccw(c16.13,96.934) 16.13,100 0,100

## Design rules (kind name [scope] priority, off if disabled: settings)
BoardOutlineClearance [All] p1: gap=0.5 ignorepadtopadclearanceinfootprint=FALSE except(0: Arc-SplitContinuation Track-SplitContinuation SMDPad-SplitContinuation THPad-SplitContinuation Via-SplitContinuation Fill-SplitContinuation Poly-SplitContinuation Region-SplitContinuation Text-SplitContinuation)
Clearance Clearance_poly_Z [InPolygon vs InNetClass('B0_SE40') OR InNetClass('B1_SE40') OR InNetClass('B2_SE40') OR InNetClass('B3_SE40') OR InNetClass('SE40') OR InNetClass('SE45_HAX')] p1: gap=0.7 ignorepadtopadclearanceinfootprint=FALSE // polygon to impedance controlled line
Clearance Clearance_poly_diff [InPolygon vs (InDifferentialPairClass('All Differential Pairs'))] p2: gap=0.8 ignorepadtopadclearanceinfootprint=FALSE // Polygon to diff pair rule
Clearance Clearance_NPTH [PadIsPlated = 'False'] p3: gap=0.3 ignorepadtopadclearanceinfootprint=FALSE
Clearance "Clearance_Edge Connector" [(InComponentClass('Edge Connector')) vs (InComponentClass('Edge Connector'))] p4: gap=0.2 ignorepadtopadclearanceinfootprint=FALSE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance "Basic Clearance" [All] p5: gap=0.1 ignorepadtopadclearanceinfootprint=FALSE except(0.2: Arc-Poly Arc-Region Arc-Hole Track-Poly Track-Region Track-Hole SMDPad-Poly SMDPad-Region SMDPad-Hole THPad-Poly THPad-Region THPad-Hole Via-Poly Via-Region Via-Hole Fill-Poly Fill-Region Fill-Hole Poly-Poly Poly-Region Poly-Hole Region-Region Region-Hole Text-Hole) // basic clearance rule
Clearance Clearance_internal_plane [InPolygon] p6: gap=0.2 ignorepadtopadclearanceinfootprint=FALSE
ComponentClearance [All] p1 off: gap=0.254 collisioncheckmode=3 verticalgap=0.254 showdistances=FALSE
DiffPairsRouting DiffPairsRouting_PCIE [InDifferentialPairClass('PCIE')] p1: maxlimit=0.2 minlimit=0.1 mostfreqgap=0.1 toplayer_minwidth=0.1 toplayer_maxwidth=0.15 toplayer_prefwidth=0.101 midlayer1_minwidth=0.1 midlayer1_maxwidth=0.15 midlayer1_prefwidth=0.101 midlayer2_minwidth=0.1 midlayer2_maxwidth=0.15 midlayer2_prefwidth=0.101 bottomlayer_minwidth=0.1 bottomlayer_maxwidth=0.15 bottomlayer_prefwidth=0.101 maxuncoupledlength=12
DiffPairsRouting DiffPairsRouting_100DP [(InNetClass('HDMI_CNR') OR InNetClass('HDMI_TX'))] p2: maxlimit=0.25 minlimit=0.1 mostfreqgap=0.2 toplayer_minwidth=0.1 toplayer_maxwidth=0.18 toplayer_prefwidth=0.1 midlayer1_prefgap=0.1 midlayer1_minwidth=0.1 midlayer1_maxwidth=0.18 midlayer1_prefwidth=0.1 midlayer2_minwidth=0.1 midlayer2_maxwidth=0.18 midlayer2_prefwidth=0.1 bottomlayer_minwidth=0.1 bottomlayer_maxwidth=0.18 bottomlayer_prefwidth=0.1 maxuncoupledlength=6 // 100 ohm DP rule
DiffPairsRouting DiffPairsRouting_90DP [InDifferentialPair('USB_D') OR InDifferentialPairClass('HAX_DP') OR InDifferentialPairClass('PCI_DP') OR InDifferentialPairClass('USB')] p3: maxlimit=0.25 minlimit=0.1 mostfreqgap=0.1 toplayer_minwidth=0.1 toplayer_maxwidth=0.225 toplayer_prefwidth=0.1 midlayer1_minwidth=0.1 midlayer1_maxwidth=0.18 midlayer1_prefwidth=0.1 midlayer2_minwidth=0.1 midlayer2_maxwidth=0.18 midlayer2_prefwidth=0.1 bottomlayer_minwidth=0.1 bottomlayer_maxwidth=0.225 bottomlayer_prefwidth=0.1 maxuncoupledlength=6 // 90 ohm diff pair
DiffPairsRouting DiffPairsRouting_80DP [InDifferentialPair('DDR3_CK') OR InDifferentialPair('DDR3_DQS0') OR InDifferentialPair('DDR3_DQS1') OR InDifferentialPair('DDR3_DQS2') OR InDifferentialPair('DDR3_DQS3') OR InDifferentialPair('REFCLK')] p4: maxlimit=0.25 minlimit=0.1 mostfreqgap=0.1 toplayer_minwidth=0.1 toplayer_maxwidth=0.235 toplayer_prefwidth=0.1 midlayer1_minwidth=0.1 midlayer1_maxwidth=0.18 midlayer1_prefwidth=0.1 midlayer2_minwidth=0.1 midlayer2_maxwidth=0.18 midlayer2_prefwidth=0.1 bottomlayer_minwidth=0.1 bottomlayer_maxwidth=0.235 bottomlayer_prefwidth=0.1 maxuncoupledlength=6 // 80ohm DP rule
DiffPairsRouting DiffPairsRouting_generic [All] p5: maxlimit=0.25 minlimit=0.2 mostfreqgap=0.21 toplayer_mingap=0.21 toplayer_minwidth=0.1 toplayer_maxwidth=0.18 toplayer_prefwidth=0.18 midlayer1_prefgap=0.2 midlayer1_minwidth=0.092 midlayer1_maxwidth=0.18 midlayer1_prefwidth=0.092 midlayer2_prefgap=0.2 midlayer2_minwidth=0.092 midlayer2_maxwidth=0.18 midlayer2_prefwidth=0.092 bottomlayer_mingap=0.21 bottomlayer_minwidth=0.1 bottomlayer_maxwidth=0.18 bottomlayer_prefwidth=0.18 maxuncoupledlength=6 // basic diff pair rule
FabricationTestPointUsage TestPointUsage [All] p1: valid=0 allowmultiple=FALSE
FabricationTestpoint Testpoint [All] p1: side=3 testpointundercomponent=TRUE minsize=1.016 maxsize=2.54 preferedsize=1.524 minholesize=0.508 maxholesize=1.016 preferedholesize=0.813 testpointgrid=0.025 allowsidetop=TRUE allowsidebottom=TRUE usegrid=TRUE gridtolerance=0
Height "PCI Express Mini, \"Component height constraints\", Page 18, bottom side" [OnBottomLayer] p1: minheight=0 maxheight=1.35 prefheight=1.35
Height "PCI Express Mini, \"Component height constraints\", Page 18, top side" [OnTopLayer] p2: minheight=0 maxheight=2.4 prefheight=2.4
Height "PCI Express, Page 84, \"Component Height Constraints\" for solder side" [OnBottomLayer] p3: minheight=0 maxheight=2.67 prefheight=2.67
Height "PCI Express, Page 84, \"Component Height Constraints\" for component side" [OnTopLayer] p4: minheight=0 maxheight=14.47 prefheight=14.47
HoleSize [All] p1: absolutevalues=TRUE maxlimit=3 minlimit=0.25 maxpercent=80.000 minpercent=20.000
HoleToHoleClearance [All] p1: gap=0.2 allowstackedmicrovias=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_8 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p1: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_7 [InxSignalClass('DATA_BL3')] p2: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_7 [InxSignalClass('DATA_BL2')] p3: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_7 [InxSignalClass('DATA_BL1')] p4: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_7 [InxSignalClass('DATA_BL0')] p5: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_8 [InxSignalClass('ADDR_PP2')] p6: tolerance=8.5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_8 [InxSignalClass('ADDR_PP1')] p7: tolerance=8.5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_7 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p8: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_6 [InxSignalClass('DATA_BL3')] p9: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_6 [InxSignalClass('DATA_BL2')] p10: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_6 [InxSignalClass('DATA_BL1')] p11: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_6 [InxSignalClass('DATA_BL0')] p12: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_7 [InxSignalClass('ADDR_PP2')] p13: tolerance=8.5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_7 [InxSignalClass('ADDR_PP1')] p14: tolerance=8.5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_6 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p15: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_5 [InxSignalClass('DATA_BL3')] p16: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_5 [InxSignalClass('DATA_BL2')] p17: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_5 [InxSignalClass('DATA_BL1')] p18: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_5 [InxSignalClass('DATA_BL0')] p19: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_6 [InxSignalClass('ADDR_PP2')] p20: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_6 [InxSignalClass('ADDR_PP1')] p21: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_5 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p22: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_4 [InxSignalClass('DATA_BL3')] p23: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_4 [InxSignalClass('DATA_BL2')] p24: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_4 [InxSignalClass('DATA_BL1')] p25: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_4 [InxSignalClass('DATA_BL0')] p26: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_5 [InxSignalClass('ADDR_PP2')] p27: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_5 [InxSignalClass('ADDR_PP1')] p28: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_4 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2')] p29: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_ADDR_PP2_4 [InxSignalClass('ADDR_PP2')] p30: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_4 [InxSignalClass('ADDR_PP1')] p31: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_3 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p32: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_3 [InxSignalClass('DATA_BL3')] p33: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_3 [InxSignalClass('DATA_BL2')] p34: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_3 [InxSignalClass('DATA_BL1')] p35: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_3 [InxSignalClass('DATA_BL0')] p36: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_3 [InxSignalClass('ADDR_PP2')] p37: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_3 [InxSignalClass('ADDR_PP1')] p38: tolerance=5 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_2 [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p39: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_2 [InxSignalClass('DATA_BL3')] p40: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_2 [InxSignalClass('DATA_BL2')] p41: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_2 [InxSignalClass('DATA_BL1')] p42: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_2 [InxSignalClass('DATA_BL0')] p43: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_2 [InxSignalClass('ADDR_PP2')] p44: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_2 [InxSignalClass('ADDR_PP1')] p45: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES_1 [InxSignalClass('ADDR_PP1_1') OR InxSignalClass('ADDR_PP2_1') OR InxSignalClass('DATA_BL0_1') OR InxSignalClass('DATA_BL1_1') OR InxSignalClass('DATA_BL2_1') OR InxSignalClass('DATA_BL3_1')] p46: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3_1 [InxSignalClass('DATA_BL3_1')] p47: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2_1 [InxSignalClass('DATA_BL2_1')] p48: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1_1 [InxSignalClass('DATA_BL1_1')] p49: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0_1 [InxSignalClass('DATA_BL0_1')] p50: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2_1 [InxSignalClass('ADDR_PP2_1')] p51: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1_1 [InxSignalClass('ADDR_PP1_1')] p52: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DDR_CLOCKS_STROBES [InxSignalClass('ADDR_PP1') OR InxSignalClass('ADDR_PP2') OR InxSignalClass('DATA_BL0') OR InxSignalClass('DATA_BL1') OR InxSignalClass('DATA_BL2') OR InxSignalClass('DATA_BL3')] p53: tolerance=0.6 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths MatchedLengths_DATA_BL3 [InxSignalClass('DATA_BL3')] p54: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL2 [InxSignalClass('DATA_BL2')] p55: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL1 [InxSignalClass('DATA_BL1')] p56: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_DATA_BL0 [InxSignalClass('DATA_BL0')] p57: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP2 [InxSignalClass('ADDR_PP2')] p58: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths MatchedLengths_ADDR_PP1 [InxSignalClass('ADDR_PP1')] p59: tolerance=10 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths "Schematic Matched Net Lengths_1" [InNet('RX0_TMDS2_P')] p60: tolerance=0.051 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths "Schematic Matched Net Lengths" [InNet('OV0_TMDS2_P')] p61: tolerance=0.051 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths "Schematic Matched Net Lengths_5" [InNet('TX0_TMDS3_N')] p62: tolerance=1.016 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths "Schematic Matched Net Lengths_4" [InNet('TX0_TMDS2_P')] p63: tolerance=1.016 checknetsindiffpair=FALSE checkdiffpairvsdiffpair=TRUE checkxsignals=TRUE checkothers=TRUE
MatchedLengths "Schematic Matched Net Lengths_3" [InNet('TX0_TMDS3_N')] p64: tolerance=0.051 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MatchedLengths "Schematic Matched Net Lengths_2" [InNet('TX0_TMDS2_P')] p65: tolerance=0.051 checknetsindiffpair=TRUE checkdiffpairvsdiffpair=FALSE checkxsignals=FALSE checkothers=FALSE
MinimumAnnularRing [All] p1: minimumring=0.05
MinimumSolderMaskSliver [All] p1: minsoldermaskwidth=0.07
PlaneClearance [All] p1: clearance=0.24
PlaneConnect [All] p1: planeconnectstyle=Direct reliefexpansion=0.508 reliefentries=4 reliefconductorwidth=0.254 reliefairgap=0.254
PolygonConnect [All] p1: thpad.connectstyle=Relief thpad.reliefconductorwidth=0.3 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=0.2 smdpad.connectstyle=Relief smdpad.reliefconductorwidth=0.2 smdpad.reliefentries=4 smdpad.polygonreliefangle="45 Angle" smdpad.airgapwidth=0.15 via.connectstyle=Direct via.reliefconductorwidth=0.25 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=0.15
RoomDefinition 05io [InComponentClass('05io')] p1 off: confinementstyle=ConfineIn formatcopy=TRUE lockcomponents=FALSE outline -100,-100 -49.2,-100 -49.2,-74.6 -100,-74.6
RoomDefinition 04ddr3 [InComponentClass('04ddr3')] p2 off: confinementstyle=ConfineIn formatcopy=TRUE lockcomponents=FALSE outline -100,-100 -49.2,-100 -49.2,-74.6 -100,-74.6
RoomDefinition 03fpga [InComponentClass('03fpga')] p3 off: confinementstyle=ConfineIn formatcopy=TRUE lockcomponents=FALSE outline -100,-100 -49.2,-100 -49.2,-74.6 -100,-74.6
RoomDefinition 02config [InComponentClass('02config')] p4 off: confinementstyle=ConfineIn formatcopy=TRUE lockcomponents=FALSE outline -100,-100 -49.2,-100 -49.2,-74.6 -100,-74.6
RoomDefinition 01power [InComponentClass('01power')] p5 off: confinementstyle=ConfineIn formatcopy=TRUE lockcomponents=FALSE outline -100,-100 -49.2,-100 -49.2,-74.6 -100,-74.6
RoutingTopology RoutingTopology_DDRAddressAndControls [InNetClass('DDR_AddressAndControls')] p1: topology=Daisy_Simple
RoutingTopology [All] p2: topology=Shortest
RoutingVias [All] p1: holewidth=0.25 width=0.5 viastyle="Through Hole" minholewidth=0.2 minwidth=0.45 maxholewidth=0.35 maxwidth=0.7
ShortCircuit ShortCircuit_mounting [InComponent('P10X') or InComponent('P11X') vs OnLayer('KeepOutLayer')] p1: allowed=TRUE
ShortCircuit [All] p2: allowed=FALSE
SilkToSilkClearance [All] p1 off: silktosilkclearance=0.254
SilkToSolderMaskClearance SilkscreenOverComponentPads [IsPad] p1 off: minsilkscreentomaskgap=0.254 clearancetoexposedcopper=TRUE
SolderMaskExpansion [All] p1: expansion=0.07
SupplyNets SupplyNets_3 [InNet('VTT')] p1: voltage=750.0m
SupplyNets SupplyNets_2 [InNet('P1.5V_IO')] p2: voltage=1.500
SupplyNets SupplyNets_1 [InNet('P1.5V_D')] p3: voltage=1.500
SupplyNets [InNet('P1.5V')] p4: voltage=1.500
Width Width_45SE [InNetClass('SE45_HAX')] p1: maxlimit=2 minlimit=0.1 preferedwidth=0.1 minimp=50.000000 maximp=50.000000 favimp=50.000000 // 45 ohm SE rule
Width Width_40SE [(InNetClass('B0_SE40') OR InNetClass('B1_SE40') OR InNetClass('B2_SE40') OR InNetClass('B3_SE40') OR InNetClass('SE40'))] p2: maxlimit=2 minlimit=0.1 preferedwidth=0.15 minimp=50.000000 maximp=50.000000 favimp=50.000000 // 40 ohm SE lines
Width Width_basic [All] p3: maxlimit=2 minlimit=0.1 preferedwidth=0.1 minimp=50.000000 maximp=50.000000 favimp=50.000000
16 further rules are at their usual default settings.

## Classes and differential pairs
differential pair class PCIE: HAX_CLK PCICLK PER0 PER1 PER2 PER3 PERC0 PERC1 PERC2 PERC3 PET0 PET1 PET2 PET3 REFCLK
component class 01power: C10P C11P C12P C13P C14P C15P C16P C17P C18P C19P C20P C21P C22P C23P C24P C25P C26P C27P C28P C29P C30P C31P C32P C33P C34P C35P C37P C38P C39P D10P D11P JP10P L10P L11P L12P L13P L14P NT10P R10P R11P R12P R13P R14P R15P R16P R17P R18P R19P R20P R21P R22P R23P R24P R25P R26P R27P R28P R29P R30P R31P R32P U10P U11P U12P U13P U14P U15P U16P
component class 02config: C10C C11C C12C C13C C16C C17C C18C C19C C20C C21C C22C C23C D10C P10C P11C P12C R10C R11C R12C R13C R14C R15C R16C R17C R18C R19C R20C R21C R22C R23C R24C R25C R26C SW10C U10C U11C Y10C
component class 03fpga: C10F C11F C12F C13F C14F C15F C16F C17F C18F C19F C20F C21F C22F C23F C24F C25F C26F C27F C28F C29F C30F C31F C32F C33F C34F C35F C36F C37F C38F C39F C40F C41F C42F C43F C44F C45F C46F C47F C48F C49F C50F C51F C52F C53F C54F C55F C56F C57F C58F C59F C60F C61F C62F C63F C64F C65F C66F C67F C68F C69F C70F C71F C72F C73F C74F C75F C76F C77F C78F C79F C80F C81F C82F C83F C84F C85F C86F C87F C88F C89F D10F D11F D12F P10F R10F R11F R12F R13F R14F R15F R16F R17F R18F U10F U11F
component class 04ddr3: C10D C11D C12D C13D C14D C15D C16D C17D C18D C19D C20D C21D C22D C23D C24D C25D C26D C27D C28D C29D C30D C31D C32D C33D C34D C35D C36D C37D C38D C39D C40D C41D C42D C43D C44D C45D C46D C47D C48D C49D C50D C51D R10D R11D R12D R13D R14D RP10D RP11D RP12D RP13D RP14D RP15D U10D U11D
component class 05io: C10H C11H C12H D10H D11H D12H D13H D14H D15H D16H D17H D18H D19H D20H D21H D22H D23H F10H F11H J10H J11H J12H P10H P11H P12H P13H Q10H Q11H Q12H Q13H Q14H Q15H Q16H Q17H Q18H R10H R11H R12H R13H R14H R15H R16H R17H R18H R19H R20H R21H R22H R23H R24H R25H R26H R27H R28H R29H R30H R31H R32H R33H R34H R35H R36H R37H R38H R39H R40H R41H R42H R43H R44H TP10H TP11H TP12H TP13H U10H
net class B0_DP80: DDR3_DQS0_N DDR3_DQS0_P
net class B0_SE40: DDR3_DM0 DDR3_DQ0 DDR3_DQ1 DDR3_DQ2 DDR3_DQ3 DDR3_DQ4 DDR3_DQ5 DDR3_DQ6 DDR3_DQ7
net class B1_DP80: DDR3_DQS1_N DDR3_DQS1_P
net class B1_SE40: DDR3_DM1 DDR3_DQ8 DDR3_DQ9 DDR3_DQ10 DDR3_DQ11 DDR3_DQ12 DDR3_DQ13 DDR3_DQ14 DDR3_DQ15
net class B2_DP80: DDR3_DQS2_N DDR3_DQS2_P
net class B2_SE40: DDR3_DM2 DDR3_DQ16 DDR3_DQ17 DDR3_DQ18 DDR3_DQ19 DDR3_DQ20 DDR3_DQ21 DDR3_DQ22 DDR3_DQ23
net class B3_DP80: DDR3_DQS3_N DDR3_DQS3_P
net class B3_SE40: DDR3_DM3 DDR3_DQ24 DDR3_DQ25 DDR3_DQ26 DDR3_DQ27 DDR3_DQ28 DDR3_DQ29 DDR3_DQ30 DDR3_DQ31
net class DP80: DDR3_CK_N DDR3_CK_P
net class HDMI_CNR: OV0_TMDS0_N OV0_TMDS0_P OV0_TMDS1_N OV0_TMDS1_P OV0_TMDS2_N OV0_TMDS2_P OV0_TMDS3_N OV0_TMDS3_P RX0_TMDS0_N RX0_TMDS0_P RX0_TMDS1_N RX0_TMDS1_P RX0_TMDS2_N RX0_TMDS2_P RX0_TMDS3_N RX0_TMDS3_P
net class HDMI_TX: TX0_TMDS0_N TX0_TMDS0_P TX0_TMDS1_N TX0_TMDS1_P TX0_TMDS2_N TX0_TMDS2_P TX0_TMDS3_N TX0_TMDS3_P TX1_CLK_N TX1_CLK_P TX1_TMDS0_N TX1_TMDS0_P TX1_TMDS1_N TX1_TMDS1_P TX1_TMDS2_N TX1_TMDS2_P
net class PCIE_CLK: HAX_CLK_N HAX_CLK_P PCICLK_N PCICLK_P REFCLK_N REFCLK_P
net class PCIE_DAT: PER0_N PER0_P PER1_N PER1_P PER2_N PER2_P PER3_N PER3_P PERC0_N PERC0_P PERC1_N PERC1_P PERC2_N PERC2_P PERC3_N PERC3_P PET0_N PET0_P PET1_N PET1_P PET2_N PET2_P PET3_N PET3_P
net class SE40: DDR3_A0 DDR3_A1 DDR3_A2 DDR3_A3 DDR3_A4 DDR3_A5 DDR3_A6 DDR3_A7 DDR3_A8 DDR3_A9 DDR3_A10 DDR3_A11 DDR3_A12 DDR3_A13 DDR3_BA0 DDR3_BA1 DDR3_BA2 DDR3_CAS_N DDR3_CKE DDR3_CS0_N DDR3_ODT0 DDR3_RAS_N DDR3_WE_N
differential pair class USB: FUSB FUSBD USB0 USBD
net class USB_NETS: FUSB_N FUSB_P FUSBD_N FUSBD_P USB0_N USB0_P USBD_N USBD_P
differential pair RX0_TMDS3: +RX0_TMDS3_P -RX0_TMDS3_N
differential pair RX0_TMDS2: +RX0_TMDS2_P -RX0_TMDS2_N
differential pair RX0_TMDS1: +RX0_TMDS1_P -RX0_TMDS1_N
differential pair RX0_TMDS0: +RX0_TMDS0_P -RX0_TMDS0_N
differential pair OV0_TMDS3: +OV0_TMDS3_P -OV0_TMDS3_N
differential pair OV0_TMDS2: +OV0_TMDS2_P -OV0_TMDS2_N
differential pair OV0_TMDS1: +OV0_TMDS1_P -OV0_TMDS1_N
differential pair OV0_TMDS0: +OV0_TMDS0_P -OV0_TMDS0_N
differential pair PET3: +PET3_P -PET3_N
differential pair PET2: +PET2_P -PET2_N
differential pair PET1: +PET1_P -PET1_N
differential pair PET0: +PET0_P -PET0_N
differential pair PER3: +PER3_P -PER3_N
differential pair PER2: +PER2_P -PER2_N
differential pair PER1: +PER1_P -PER1_N
differential pair PER0: +PER0_P -PER0_N
differential pair DDR3_CK: +DDR3_CK_P -DDR3_CK_N
differential pair DDR3_DQS0: +DDR3_DQS0_P -DDR3_DQS0_N
differential pair DDR3_DQS1: +DDR3_DQS1_P -DDR3_DQS1_N
differential pair DDR3_DQS2: +DDR3_DQS2_P -DDR3_DQS2_N
differential pair DDR3_DQS3: +DDR3_DQS3_P -DDR3_DQS3_N
differential pair FUSBD: +FUSBD_P -FUSBD_N
differential pair HAX_CLK: +HAX_CLK_P -HAX_CLK_N
differential pair PCICLK: +PCICLK_P -PCICLK_N
differential pair PERC0: +PERC3_P -PERC3_N
differential pair PERC1: +PERC0_P -PERC0_N
differential pair PERC2: +PERC1_P -PERC1_N
differential pair PERC3: +PERC2_P -PERC2_N
differential pair REFCLK: +REFCLK_P -REFCLK_N
differential pair TX0_TMDS0: +TX0_TMDS0_P -TX0_TMDS0_N
differential pair TX0_TMDS1: +TX0_TMDS1_P -TX0_TMDS1_N
differential pair TX0_TMDS2: +TX0_TMDS2_P -TX0_TMDS2_N
differential pair TX0_TMDS3: +TX0_TMDS3_P -TX0_TMDS3_N
differential pair USB0: +USB0_P -USB0_N
differential pair USBD: +USBD_P -USBD_N
differential pair TX1_CLK: +TX1_CLK_P -TX1_CLK_N
differential pair TX1_TMDS0: +TX1_TMDS0_P -TX1_TMDS0_N
differential pair TX1_TMDS1: +TX1_TMDS1_P -TX1_TMDS1_N
differential pair TX1_TMDS2: +TX1_TMDS2_P -TX1_TMDS2_N
differential pair FUSB: +FUSB_P -FUSB_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C10C "0.1uF, 6.3V, X5R" CAPC0603X03L 27.9,63.225 r90 top
C10D "4.7uF, 6.3V, X5R" CAPC1005N 56.5,58.475 r225 bottom
C10F "4.7uF, 6.3V, X5R" CAPC1005N 43.775,38.3 r90 bottom
C10H "0.1uF, 6.3V, X5R" CAPC0603X03L 21.4,63.3 r90 bottom
C10P "10uF, 6.3V, X5R" CAPC1608N 60.95,35.475 r270 top
C11C "10uF, 6.3V, X5R" CAPC1608N 77.575,39.65 r90 bottom
C11D "0.1uF, 6.3V, X5R" CAPC0603X03L 54.947,56.493 r225 bottom
C11F "0.1uF, 6.3V, X5R" CAPC0603X03L 38.825,38.675 r90 bottom
C11H "10uF, 6.3V, X5R" CAPC1608N 78.325,70.375 r270 top
C11P "10nF, 25V, X7R" CAPC1005N 59.45,35.475 r270 top
C12C "0.1uF, 6.3V, X5R" CAPC0603X03L 80.55,37.55 r0 top
C12D "0.1uF, 6.3V, X5R" CAPC0603X03L 62.867,48.573 r225 top
C12F "0.1uF, 6.3V, X5R" CAPC0603X03L 41.75,33.975 r315 bottom
C12H "0.1uF, 6.3V, X5R" CAPC0603X03L 64.425,76.475 r180 top
C12P "10uF, 6.3V, X5R" CAPC1608N 42.475,16.125 r180 top
C13C "10uF, 10V, X5R (DNP)" CAPC2012N 77.575,35.95 r270 bottom
C13D "100uF, 6.3V, X5R" CAPC3216N 74.88,53.871 r315 top
C13F "0.47uF, 6.3V, X5R" CAPC0603X03L 33.875,49.25 r90 bottom
C13P "10nF, 25V, X7R" CAPC1005N 42.45,17.65 r180 top
C14D "0.1uF, 6.3V, X5R" CAPC0603X03L 59.473,45.179 r45 top
C14F "0.47uF, 6.3V, X5R" CAPC0603X03L 37.7,51.525 r45 bottom
C14P "10uF, 6.3V, X5R" CAPC1608N 53.825,35.5 r270 top
C15D "4.7uF, 6.3V, X5R" CAPC1005N 58.978,62.22 r45 top
C15F "0.1uF, 6.3V, X5R" CAPC0603X03L 42.4,32.675 r225 bottom
C15P "10uF, 6.3V, X5R" CAPC1608N 55.525,35.5 r270 top
C16C "0.1uF, 6.3V, X5R" CAPC0603X03L 86.225,46.725 r0 top
C16D "0.1uF, 6.3V, X5R" CAPC0603X03L 58.342,59.887 r45 top
C16F "0.1uF, 6.3V, X5R" CAPC0603X03L 48.45,39.075 r90 bottom
C16P "10uF, 6.3V, X5R" CAPC1608N 42.475,23.175 r180 top
C17C "10uF, 6.3V, X5R" CAPC1608N 63.55,32.5 r90 top
C17D "0.1uF, 6.3V, X5R" CAPC0603X03L 60.604,46.31 r45 top
C17F "4.7uF, 6.3V, X5R" CAPC1005N 44.575,33.725 r315 bottom
C17P "10uF, 6.3V, X5R" CAPC1608N 42.475,21.575 r180 top
C18C "0.1uF, 6.3V, X5R" CAPC0603X03L 73.25,45.45 r90 top
C18D "0.1uF, 6.3V, X5R" CAPC0603X03L 54.947,56.493 r225 top
C18F "0.47uF, 6.3V, X5R" CAPC0603X03L 45.675,39.5 r225 bottom
C18P "10uF, 6.3V, X5R" CAPC1608N 69.175,70.525 r0 top
C19C "0.1uF, 6.3V, X5R" CAPC0603X03L 64.8,33.35 r90 top
C19D "0.1uF, 6.3V, X5R" CAPC0603X03L 66.261,51.967 r45 top
C19F "0.47uF, 6.3V, X5R" CAPC0603X03L 39.925,43.625 r225 bottom
C19P "10nF, 25V, X7R" CAPC1005N 69.175,69 r0 top
C20C "0.1uF, 6.3V, X5R" CAPC0603X03L 79.35,34.4 r90 top
C20D "4.7uF, 6.3V, X5R" CAPC1005N 67.7,45.7 r45 top
C20F "0.1uF, 6.3V, X5R" CAPC0603X03L 50.196,35.007 r135 bottom
C20P "10uF, 6.3V, X5R" CAPC1608N 84.675,70.9 r0 top
C21C "0.1uF, 6.3V, X5R" CAPC0603X03L 69.125,44.55 r180 top
C21D "4.7uF, 6.3V, X5R" CAPC1005N 58.978,62.22 r45 bottom
C21F "0.1uF, 6.3V, X5R" CAPC0603X03L 45.584,31.03 r315 bottom
C21P "10nF, 25V, X7R" CAPC1005N 84.675,69.425 r0 top
C22C "10uF, 6.3V, X5R" CAPC1608N 80.6,41.55 r90 top
C22D "0.22uF, 6.3V, X5R" CAPC0603X03L 67.463,53.169 r45 top
C22F "0.1uF, 6.3V, X5R" CAPC0603X03L 50.656,35.466 r135 bottom
C22P "10uF, 6.3V, X5R" CAPC1608N 69.15,63.375 r0 top
C23C "0.1uF, 6.3V, X5R" CAPC0603X03L 79.3,40.65 r90 top
C23D "0.22uF, 6.3V, X5R" CAPC0603X03L 61.736,47.442 r225 top
C23F "0.1uF, 6.3V, X5R" CAPC0603X03L 46.044,31.49 r315 bottom
C23P "10uF, 6.3V, X5R" CAPC1608N 69.15,65.125 r0 top
C24D "0.22uF, 6.3V, X5R" CAPC0603X03L 58.342,59.887 r45 bottom
C24F "0.1uF, 6.3V, X5R" CAPC0603X03L 48.576,32.916 r135 bottom
C24P "10uF, 6.3V, X5R" CAPC1608N 84.625,65.475 r0 top
C25D "0.22uF, 6.3V, X5R" CAPC0603X03L 53.816,55.361 r45 top
C25F "0.1uF, 6.3V, X5R" CAPC0603X03L 49.036,33.376 r135 bottom
C25P "10uF, 6.3V, X5R" CAPC1608N 84.625,63.875 r0 top
C26D "4.7uF, 6.3V, X5R" CAPC1005N 70.455,48.446 r225 top
C26F "0.47uF, 6.3V, X5R" CAPC0603X03L 33.425,39.7 r180 bottom
C26P "1.0uF, 6.3V, X5R" CAPC0603X03L 52.025,31.725 r270 top
C27D "0.1uF, 6.3V, X5R" CAPC0603X03L 67.675,48.856 r315 top
C27F "0.1uF, 6.3V, X5R" CAPC0603X03L 49.768,33.579 r135 bottom
C27P "1.0uF, 6.3V, X5R" CAPC0603X03L 54.175,31.825 r270 top
C28D "4.7uF, 6.3V, X5R" CAPC1005N 72.655,50.671 r225 top
C28F "4.7uF, 6.3V, X5R" CAPC1005N 31.725,41.825 r180 bottom
C28P "0.1uF, 50V, X7R" CAPC2012N 18.545,76 r90 top
C29D "0.1uF, 6.3V, X5R" CAPC0603X03L 70.15,51.331 r315 top
C29F "4.7uF, 6.3V, X5R" CAPC1005N 37.1,36.725 r315 bottom
C29P "10uF, 6.3V, X5R" CAPC1608N 76.125,57.4 r45 top
C30D "4.7uF, 6.3V, X5R" CAPC1005N 64.825,50.325 r225 top
C30F "0.47uF, 6.3V, X5R" CAPC0603X03L 41.25,33.1 r315 bottom
C30P "10uF, 6.3V, X5R" CAPC1608N 77.85,56.975 r45 top
C31D "0.1uF, 6.3V, X5R" CAPC0603X03L 57.069,59.18 r135 top
C31F "0.47uF, 6.3V, X5R" CAPC0603X03L 39.125,35.45 r0 bottom
C31P "0.22uF, 6.3V, X5R" CAPC0603X03L 74.975,61.1 r315 top
C32D "0.1uF, 6.3V, X5R" CAPC0603X03L 65.554,50.694 r315 bottom
C32F "0.47uF, 6.3V, X5R" CAPC0603X03L 37.7,38.45 r225 bottom
C32P "10uF, 50V, X7R" CAPC3216N 16.325,69.4 r0 top
C33D "0.1uF, 6.3V, X5R" CAPC0603X03L 65.2,46.381 r315 bottom
C33F "0.47uF, 6.3V, X5R" CAPC0603X03L 38.45,37.225 r315 bottom
C33P "0.1uF, 50V, X7R" CAPC2012N 15.825,71.625 r180 top
C34D "0.1uF, 6.3V, X5R" CAPC0603X03L 72.625,53.806 r315 top
C34F "0.47uF, 6.3V, X5R" CAPC0603X03L 36.025,38.825 r0 bottom
C34P "22uF, 25V, X5R" CAPC3216N 9.275,70.525 r270 top
C35D "0.1uF, 6.3V, X5R" CAPC0603X03L 65.2,46.381 r315 top
C35F "100uF, 6.3V, X5R" CAPC3216N 42.975,26.425 r225 top
C35P "22uF, 25V, X5R" CAPC3216N 11.6,70.525 r270 top
C36D "0.1uF, 6.3V, X5R" CAPC0603X03L 59.544,61.089 r45 bottom
C36F "0.1uF, 6.3V, X5R" CAPC0603X03L 50.228,34.038 r135 bottom
C37D "4.7uF, 6.3V, X5R" CAPC1005N 51.907,53.876 r225 top
C37F "0.1uF, 6.3V, X5R" CAPC0603X03L 46.945,32.69 r135 bottom
C37P "0.1uF, 6.3V, X5R" CAPC0603X03L 71.775,58.675 r315 top
C38D "0.1uF, 6.3V, X5R" CAPC0603X03L 67.463,53.169 r45 bottom
C38F "4.7uF, 6.3V, X5R" CAPC1005N 40.15,39.05 r270 bottom
C38P "0.1uF, 50V, X7R" CAPC2012N 17.5,85.75 r270 top
C39D "0.1uF, 6.3V, X5R" CAPC0603X03L 62.867,48.573 r225 bottom
C39F "0.47uF, 6.3V, X5R" CAPC0603X03L 34.65,40.65 r180 bottom
C39P "75pF, 50V, NP0" CAPC1005N 17.625,80.275 r180 top
C40D "0.1uF, 6.3V, X5R" CAPC0603X03L 61.736,47.442 r225 bottom
C40F "0.1uF, 6.3V, X5R" CAPC0603X03L 47.404,33.15 r135 bottom
C41D "0.1uF, 6.3V, X5R" CAPC0603X03L 66.261,51.967 r45 bottom
C41F "0.47uF, 6.3V, X5R" CAPC0603X03L 40.225,41.125 r315 bottom
C42D "0.1uF, 6.3V, X5R" CAPC0603X03L 67.675,48.856 r315 bottom
C42F "0.47uF, 6.3V, X5R" CAPC0603X03L 36.075,42.45 r315 bottom
C43D "0.1uF, 6.3V, X5R" CAPC0603X03L 70.15,51.331 r315 bottom
C43F "0.47uF, 6.3V, X5R" CAPC0603X03L 38.8,42.55 r315 bottom
C44D "4.7uF, 6.3V, X5R" CAPC1005N 60.251,45.532 r225 bottom
C44F "0.47uF, 6.3V, X5R" CAPC0603X03L 45.275,38.125 r0 bottom
C45D "0.22uF, 6.3V, X5R" CAPC0603X03L 59.544,61.089 r45 top
C45F "0.47uF, 6.3V, X5R" CAPC0603X03L 37.725,39.725 r0 bottom
C46D "0.22uF, 6.3V, X5R" CAPC0603X03L 53.816,55.361 r225 bottom
C46F "4.7uF, 6.3V, X5R" CAPC1005N 33.85,43.975 r180 bottom
C47D "0.22uF, 6.3V, X5R" CAPC0603X03L 52.685,54.23 r45 bottom
C47F "4.7uF, 6.3V, X5R" CAPC1005N 36,44.675 r90 bottom
C48D "0.22uF, 6.3V, X5R" CAPC0603X03L 51.553,53.098 r45 bottom
C48F "4.7uF, 6.3V, X5R" CAPC1005N 41.025,36.825 r90 bottom
C49D "100uF, 6.3V, X5R" CAPC3216N 33.125,54.525 r225 bottom
C49F "100uF, 6.3V, X5R" CAPC3216N 54.975,38.475 r0 bottom
C50D "0.1uF, 6.3V, X5R" CAPC0603X03L 66.025,43.3 r135 top
C50F "100uF, 6.3V, X5R" CAPC3216N 30.075,24.075 r180 bottom
C51D "3.3pF, NP0" CAPC0603X03L 63.425,45.85 r225 top
C51F "0.47uF, 6.3V, X5R" CAPC0603X03L 27.8,37.55 r0 bottom
C52F "0.47uF, 6.3V, X5R" CAPC0603X03L 32.5,32.425 r0 bottom
C53F "0.47uF, 6.3V, X5R" CAPC0603X03L 30.625,35.625 r0 bottom
C54F "0.47uF, 6.3V, X5R" CAPC0603X03L 35.25,27.05 r90 bottom
C55F "0.47uF, 6.3V, X5R" CAPC0603X03L 35.2,34.075 r90 bottom
C56F "4.7uF, 6.3V, X5R" CAPC1005N 30.82,26.69 r180 bottom
C57F "4.7uF, 6.3V, X5R" CAPC1005N 31.05,34.09 r180 bottom
C58F "4.7uF, 6.3V, X5R" CAPC1005N 31.05,43.975 r180 bottom
C59F "0.47uF, 6.3V, X5R" CAPC0603X03L 41.55,41 r225 bottom
C60F "0.47uF, 6.3V, X5R" CAPC0603X03L 42.675,47.275 r315 bottom
C61F "0.47uF, 6.3V, X5R" CAPC0603X03L 35.325,46.975 r270 bottom
C62F "0.47uF, 6.3V, X5R" CAPC0603X03L 39.2,44.275 r225 bottom
C63F "4.7uF, 6.3V, X5R" CAPC1005N 39.525,51.125 r90 bottom
C64F "4.7uF, 6.3V, X5R" CAPC1005N 43.8,44.85 r90 bottom
C65F "4.7uF, 6.3V, X5R" CAPC1005N 50.7,39.875 r270 bottom
C66F "0.47uF, 6.3V, X5R" CAPC0603X03L 32.225,42.975 r45 bottom
C67F "0.47uF, 6.3V, X5R" CAPC0603X03L 41.675,30.525 r45 bottom
C68F "0.47uF, 6.3V, X5R" CAPC0603X03L 33.55,27.675 r0 bottom
C69F "0.47uF, 6.3V, X5R" CAPC0603X03L 38.15,28.475 r0 bottom
C70F "4.7uF, 6.3V, X5R" CAPC1005N 39.5,34.075 r0 bottom
C71F "4.7uF, 6.3V, X5R" CAPC1005N 32.249,37.899 r225 bottom
C72F "4.7uF, 6.3V, X5R" CAPC1005N 38.675,26.475 r225 bottom
C73F "0.47uF, 6.3V, X5R" CAPC0603X03L 46.4,42.75 r45 bottom
C74F "0.47uF, 6.3V, X5R" CAPC0603X03L 49.625,39.325 r270 bottom
C75F "0.47uF, 6.3V, X5R" CAPC0603X03L 36.7,52.275 r90 bottom
C76F "0.47uF, 6.3V, X5R" CAPC0603X03L 33.3,48.05 r315 bottom
C77F "4.7uF, 6.3V, X5R" CAPC1005N 40.25,46.075 r90 bottom
C78F "4.7uF, 6.3V, X5R" CAPC1005N 34.175,51.15 r225 bottom
C79F "4.7uF, 6.3V, X5R" CAPC1005N 38.125,48.275 r90 bottom
C80F "0.47uF, 6.3V, X5R" CAPC0603X03L 38.475,33 r135 bottom
C81F "0.47uF, 6.3V, X5R" CAPC0603X03L 24.38,38.56 r315 bottom
C82F "0.47uF, 6.3V, X5R" CAPC0603X03L 29.25,33.1 r0 bottom
C83F "0.47uF, 6.3V, X5R" CAPC0603X03L 24.25,42.525 r180 bottom
C84F "4.7uF, 6.3V, X5R" CAPC1005N 26.1,35.625 r45 bottom
C85F "4.7uF, 6.3V, X5R" CAPC1005N 39.125,30.2 r315 bottom
C86F "4.7uF, 6.3V, X5R" CAPC1005N 35.2,29.85 r45 bottom
C87F "0.1uF, 6.3V, X5R" CAPC0603X03L 46.5,34.875 r315 bottom
C88F "0.1uF, 6.3V, X5R" CAPC0603X03L 47.825,36.4 r315 bottom
C89F "0.1uF, 6.3V, X5R" CAPC0603X03L 36.375,34.725 r180 bottom
D10C "red LED 0805" CD2012-0805 87.075,35.325 r0 top
D10F "white LED" CD2012-0805 2,36 r270 top
D10H "RCLAMP0524P" SEMTECH_SLP2510P8 13.925,51.675 r90 top
D10P "PESD24VL1BA" SOD-323 15.1,85.6 r90 top
D11F "white LED" CD2012-0805 2,64.5 r270 top
D11H "RCLAMP0524P" SEMTECH_SLP2510P8 13.925,48.125 r270 top
D11P "white LED" CD2012-0805 2,69 r270 top
D12F "white LED" CD2012-0805 2.025,60 r270 top
D12H "RCLAMP0524P" SEMTECH_SLP2510P8 13.925,44.75 r270 top
D13H "ESD5Z5.0T1G" SOD-523 18.3,47.5 r270 bottom
D14H "RCLAMP0524P" SEMTECH_SLP2510P8 13.975,27.4 r90 top
D15H "RCLAMP0524P" SEMTECH_SLP2510P8 13.975,24 r270 top
D16H "RCLAMP0524P" SEMTECH_SLP2510P8 13.975,20.725 r270 top
D17H "RCLAMP0524P" SEMTECH_SLP2510P8 56.35,64.875 r0 top
D18H "RCLAMP0524P" SEMTECH_SLP2510P8 52.775,64.85 r180 top
D19H "RCLAMP0524P" SEMTECH_SLP2510P8 49.325,64.85 r180 top
D20H "ESD5Z5.0T1G" SOD-523 30.875,69.35 r180 bottom
D21H "RCLAMP0524P" SEMTECH_SLP2510P8 38.325,69.45 r0 top
D22H "RCLAMP0524P" SEMTECH_SLP2510P8 34.575,69.45 r180 top
D23H "RCLAMP0524P" SEMTECH_SLP2510P8 31.15,69.45 r180 top
F10H "PRG21BB150MB1RK" RESC2012N 18.7,53.8 r270 bottom
F11H "PRG21BB150MB1RK" RESC2012N 36,69.45 r180 bottom
J10H "AUK HDM19SW-4-L2-1R3HHCN" MOLEX_47151-0001 9.4,48 r270 top
J11H "AUK HDM19SW-4-L2-1R3HHCN" MOLEX_47151-0001 9.4,24 r270 top
J12H "AUK HDM19SW-4-L2-1R3HHCN" MOLEX_47151-0001 53,69.4 r180 top locked
JP10P "2.1mm x 5.5mm DC jack" CUI_PJ_002AH_SMT 7.875,81.175 r0 top
L10P "0.56uH LPS3008-561MRC" COILCRAFT_LPS3008 56.05,38.925 r180 top
L11P "0.56uH LPS3008-561MRC" COILCRAFT_LPS3008 45.875,20.925 r90 top
L12P "0.56uH LPS3008-561MRC" COILCRAFT_LPS3008 65.725,65.725 r270 top
L13P "0.56uH LPS3008-561MRC" COILCRAFT_LPS3008 81.225,66.05 r270 top
L14P "22uH MSS1038-223ML" COILCRAFT_MSS1038 18.475,62.55 r90 top
P10C "Male 4x1 2.54mm header (DNP)" HDR1X4 88.2,31.975 r270 top
P10F "Header 2 (DNP)" HDR1X2 88.2,18.85 r270 top
P10H "HDMI Type D" MOLEX_0467651301 33.6,79 r180 top
P11C "Female 10x2 2.54mm header (DNP)" HDR2X10 76.63,25.23 r180 bottom locked
P11H "Header 11X2" HDR2X11 39.1,17.45 r180 top
P12C "FCI 10103594-0001LF" USB_MICRO_B_SMT 88.4,41.3 r90 top
P12H "FCI 10103594-0001LF" USB_MICRO_B_SMT 74.4,77.3 r180 top
P13H "PCIeX4-GF-2D-1000-1K-O64" PCIeX4-GF-2D-1000-1K-O64 55.15,3.5 r0 top locked
Q10H "BSS84" SOT23-3N 15.075,31.3 r0 top
Q11H "FDV301N" SOT23-3N 8.425,34.825 r0 top
Q12H "FDV301N" SOT23-3N 12.2,36.425 r270 top
Q13H "BSS84" SOT23-3N 22.625,58.375 r225 top
Q14H "FDV301N" SOT23-3N 18.975,55.125 r180 top
Q15H "FDV301N" SOT23-3N 14.975,55.125 r180 top
Q16H "BSS138" SOT23-3N 64.4,72.45 r270 top
Q17H "BSS138" SOT23-3N 42.5,67.475 r90 top
Q18H "BSS138" SOT23-3N 41.675,74.8 r90 top
R10C "2.4k, 1%" CAPC0603X03L 26.4,71.4 r270 top
R10D "240, 1%" CAPC0603X03L 64.847,49.987 r135 bottom
R10F "1k, 1%" RESC1005N 22.4,34.8 r135 bottom
R10H "100k, 1%" RESC1005N 12.3,55.1 r270 top
R10P "0 ohm" RESC1608N 59.9,38.575 r270 top
R11C "4.7k, 1%" RESC1005N 26,60.425 r180 top
R11D "4.7k, 1%" RESC1005N 66.425,60.8 r315 top
R11F "100, 1%" RESC1005N 42.375,36.875 r270 bottom
R11H "47/RP" PANASONIC_EXB24V 30.3,27.91 r135 bottom
R11P "0 ohm" RESC1608N 45.575,16.125 r180 top
R12C "4.7k, 1%" RESC1005N 23.15,71.1 r0 top
R12D "39, 1%" RESC1005N 64.175,44.25 r315 top
R12F "4.7k, 1%" RESC1005N 33.525,36.175 r315 bottom
R12H "47/RP" PANASONIC_EXB24V 33.27,30.51 r90 bottom
R12P "100k, 1%" RESC1005N 60.275,32.925 r0 top
R13C "10k, 1%" RESC1005N 71.85,45.9 r90 top
R13D "39, 1%" RESC1005N 65.025,45.1 r315 top
R13F "4.7k, 1%" RESC1005N 29.3,41.8 r270 bottom
R13H "47/RP" PANASONIC_EXB24V 25.96,29.44 r90 bottom
R13P "100k, 1%" RESC1005N 43.975,14.775 r0 top
R14C "33, 1%" RESC1005N 81.6,35.45 r270 top
R14D "240, 1%" CAPC0603X03L 56.362,58.472 r315 top
R14F "330, 1%" RESC1005N 35.125,36.35 r135 bottom
R14H "47/RP" PANASONIC_EXB24V 32.91,33.24 r90 bottom
R14P "100k, 1%" RESC1005N 56.45,32.975 r180 top
R15C "33, 1%" RESC1005N 82.8,35.45 r270 top
R15F "1.0k, 1%" RESC1005N 32.025,45.8 r315 bottom
R15H "39, 1%" RESC1005N 23.6,32.525 r0 bottom
R15P "100k, 1%" RESC1005N 39.95,20.5 r90 top
R16C "10k, 1%" RESC1005N 72.825,47.975 r180 top
R16F "100, 1%" RESC1005N 4.8,36.95 r0 top
R16H "1k, 1%" RESC1005N 12.5,31.3 r90 top
R16P "402k, 1%" RESC1005N 56.45,31.775 r180 top
R17C "0 ohm" RESC1005N 74.7,38.5 r180 bottom
R17F "100, 1%" RESC1005N 4.85,65.45 r0 top
R17H "1k, 1%" RESC1005N 5.85,34.8 r270 top
R17P "80.6k, 1%" RESC1005N 38.75,20.5 r90 top
R18C "DNP" RESC1005N 83.275,42.925 r90 top
R18F "100, 1%" RESC1005N 4.925,60.95 r0 top
R18H "39, 1%" RESC1005N 12.75,33.775 r0 top
R18P "0 ohm" RESC1608N 68.375,72.825 r270 top
R19C "DNP" RESC1005N 80.55,38.7 r0 top
R19H "47/RP" PANASONIC_EXB24V 22.18,37.56 r45 bottom
R19P "0 ohm" RESC1608N 81.575,69.425 r0 top
R20C "100, 1%" RESC1005N 84.025,34.575 r270 top
R20H "1k, 1%" RESC1005N 12.25,39 r180 top
R20P "0 ohm" RESC1608N 52.95,30.175 r0 top
R21C "4.7k, 1%" RESC1005N 62.85,39.6 r180 top
R21H "47/RP" PANASONIC_EXB24V 23.95,41.63 r315 bottom
R21P "100k, 1%" RESC1005N 71.75,69.8 r270 top
R22C "4.7k, 1%" RESC1005N 62.85,38.375 r180 top
R22H "47/RP" PANASONIC_EXB24V 22.55,44.8 r0 bottom
R22P "100k, 1%" RESC1005N 87.225,70.2 r90 top
R23C "DNP" RESC1005N 82,49.35 r270 top
R23H "1.5k, 1%" RESC1005N 76.625,69.8 r90 top
R23P "100k, 1%" RESC1005N 71.675,66.025 r270 top
R24C "DNP" RESC1005N 64,35.55 r180 top
R24H "1.5k, 1% (DNP)" RESC1005N 72.95,69.8 r90 top
R24P "100k, 1%" RESC1005N 87.175,66.425 r270 top
R25C "DNP" RESC1005N 82.4,31.825 r0 top
R25H "47/RP" PANASONIC_EXB24V 25.55,38.31 r0 bottom
R25P "115k, 1%" RESC1005N 72.875,66.025 r270 top
R26C "DNP" RESC1005N 82.4,30.625 r0 top
R26H "39, 1%" RESC1005N 54.95,62.275 r270 top
R26P "31.6k, 1%" RESC1005N 88.375,66.425 r270 top
R27H "1k, 1%" RESC1005N 18.05,52.65 r0 top
R27P "0 ohm" RESC1608N 72.9,56.35 r225 top
R28H "39, 1%" RESC1005N 75.4,70.95 r90 top
R28P "0 ohm (DNP)" RESC1608N 81,71.45 r180 top
R29H "1k, 1%" RESC1005N 59.575,65.7 r0 top
R29P "49.9, 1%" RESC1005N 18.825,81.425 r0 top
R30H "39, 1%" RESC1005N 74.175,70.95 r90 top
R30P "100k, 1%" RESC1005N 17.625,79.125 r0 top
R31H "1k, 1%" RESC1005N 20.5,55 r90 bottom
R31P "13.3k, 1%" RESC1005N 15.1,79.125 r0 top
R32H "39, 1%" RESC1005N 21.275,57.85 r0 bottom
R32P "330, 1%" RESC1005N 4.775,68.075 r180 top
R33H "10k, 1%" RESC1005N 59.575,64.525 r0 top
R34H "1k, 1%" RESC1005N 18.2,57.1 r90 bottom
R35H "1.8k, 1%" RESC1005N 63.75,69.75 r0 top value=100k
R36H "1.8k, 1%" RESC1005N 64.525,75.175 r180 top value=100k
R37H "DNP" RESC1005N 63.625,15.5 r90 top
R38H "0 ohm" RESC1005N 77.65,15.5 r90 top
R39H "DNP" RESC1005N 72.075,72.325 r180 top
R40H "100k, 1%" RESC1005N 39.075,73.6 r270 top
R41H "1.8k, 1%" RESC1005N 42.475,70.1 r180 top value=100k
R42H "1.8k, 1%" RESC1005N 42.45,64.8 r0 top value=100k
R43H "1.8k, 1%" RESC1005N 41.675,77.4 r180 top value=100k
R44H "1.8k, 1%" RESC1005N 41.575,72.125 r0 top value=100k
RP10D "39, 5%" PANASONIC_EXB28V 67.322,47.795 r225 bottom
RP11D "39, 5%" PANASONIC_EXB28V 66.261,46.734 r45 top
RP12D "39, 5%" PANASONIC_EXB28V 69.797,50.27 r225 bottom
RP13D "39, 5%" PANASONIC_EXB28V 68.736,49.209 r45 top
RP14D "39, 5%" PANASONIC_EXB28V 72.272,52.745 r225 bottom
RP15D "39, 5%" PANASONIC_EXB28V 71.211,51.684 r45 top
SW10C "5x5mm 1.6mm tall PB" SWITCH_TS-1187A 88.075,48.65 r180 top
TP10H "test point (DNP)" TP_2MM_SQ 50.925,43.275 r90 bottom
TP11H "test point (DNP)" TP_2MM_SQ 22.15,91.65 r90 top
TP12H "test point (DNP)" TP_2MM_SQ 48.7,43.275 r0 bottom
TP13H "test point (DNP)" TP_2MM_SQ 87.4,76.3 r90 top
U10C "MX25L6436FM2I-08G" SOIC127P790X216-8N 24.5,65.75 r270 top
U10D "MT41J128M16HA-125" MICT-HA-96 59.473,53.098 r315 bottom
U10F "XC7A35T-2FGG484C" FGG484 36,39 r225 top locked
U10H "74VHC04MTC" TSOP65P640-14AN 24.65,65.625 r270 bottom
U10P "FAN53541UCX" BGA20C40P4X5_156X196X62 57.6,35.075 r180 top
U11C "K22F 64LQFP" TSQFP50P1200X1200-64N 72.05,37.225 r180 top
U11D "MT41J128M16HA-125" MICT-HA-96 59.473,53.098 r135 top
U11F "50 MHz oscillator" ABRACON_ASDMB 36.49,32.411 r225 bottom
U11P "FAN53541UCX" BGA20C40P4X5_156X196X62 42.05,19.475 r90 top
U12P "FAN53541UCX" BGA20C40P4X5_156X196X62 69.575,67.15 r270 top
U13P "FAN53541UCX" BGA20C40P4X5_156X196X62 85.075,67.575 r270 top
U14P "LP5907UVX-1.2/NOPB" TI_YKE004 53.1,32.025 r0 top
U15P "TPS51206" TI-DSQ-R-PWSON-N10 74.25,58.1 r135 top
U16P "TPS54202" SOT26A-6N 15.72,76.05 r90 top
Y10C "32.768kHz" ABS07-120 75.95,45.675 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
ABRACON_ASDMB [mm] "Abracon Miniature Pure Silicon Clock Oscillator"
  oct 0.65x0.85 smd mask+0.07: 1(-0.825,-0.775)
  rect 0.65x0.85 smd mask+0.07: 2(0.825,-0.775) 3(0.825,0.775) 4(-0.825,0.775)
  silkscreen extent -1.6,-1.1 0.3,1.1, body extent -1.25,-1 1.25,1, height 0.85
ABS07-120 [mm] "32.768kHz SMD low-ESR"
  rect 1x1.8 smd: 1(-1.25,0) 2(1.25,0)
  body extent -1.6,-0.75 1.6,0.75, height 0.9
BGA20C40P4X5_156X196X62 [mm] "BGA, 20-Leads, Body 1.56x1.96mmx0.63mm, Pitch 0.40mm"
  round 0.3 smd mask-0.05: A1(-0.6,0.8) A2(-0.2,0.8) A3(0.2,0.8) A4(0.6,0.8) B1(-0.6,0.4) B2(-0.2,0.4) B3(0.2,0.4) B4(0.6,0.4) C1(-0.6,0) C2(-0.2,0) C3(0.2,0) C4(0.6,0) D1(-0.6,-0.4) D2(-0.2,-0.4) D3(0.2,-0.4) D4(0.6,-0.4) E1(-0.6,-0.8) E2(-0.2,-0.8) E3(0.2,-0.8) E4(0.6,-0.8)
  silkscreen extent -0.93,1.04 -0.84,1.13, body extent -0.78,-0.98 0.78,0.98, height 0.63
CAPC0603X03L [mm] "Chip Capacitor, 2-Leads, Body 0.60x0.30mm, IPC High Density"
  rect 0.38x0.32 smd mask+0.07: 1(-0.35,0) 2(0.35,0)
  body extent -0.3,-0.15 0.3,0.15, height 0.3
CAPC1005N [mm] "Chip Capacitor, Body 1.0x0.5mm, IPC Medium Density"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  body extent -0.55,-0.3 0.55,0.3, height 0.6
CAPC1608N [mm] "Chip Capacitor, Body 1.6x0.8mm, IPC Medium Density"
  rect 1x1 smd: 1(-0.8,0) 2(0.8,0)
  body extent -0.87,-0.48 0.87,0.48, height 0.85
CAPC2012N [mm] "Chip Capacitor, Body 2.0x1.3mm, IPC Medium Density"
  rect 1.15x1.5 smd: 1(-1,0) 2(1,0)
  body extent -1.1,-0.72 1.1,0.72, height 1.1
CAPC3216N [mm] "Chip Capacitor, Body 3.2x1.6mm, IPC Medium Density"
  rect 1.3x1.8 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -0.4,-0.8 0.4,0.8, body extent -1.7,-0.9 1.7,0.9, height 1.35
CD2012-0805 [mm] "Chip Diode; Body 2.0 x 1.3 mm (LxW typ)"
  rect 1.3x1.5 smd: 1(-0.95,0) 2(0.95,0)
  silkscreen extent 1.9,-0.65 1.9,0.65
COILCRAFT_LPS3008 [mm] "3x3x0.8mm inductor"
  rect 0.4x1 smd: 1(-1.257,0) 2(1.257,0)
  L1 region: -0.495,1.499 -1.384,1.499 -1.638,1.245 -1.638,-1.295 -1.384,-1.549 -0.495,-1.549 -0.495,-0.838 -0.876,-0.533 -0.876,0.483 -0.495,0.787
  L1 region: 0.521,-1.549 1.41,-1.549 1.664,-1.295 1.664,1.245 1.41,1.499 0.521,1.499 0.521,0.787 0.902,0.483 0.902,-0.533 0.521,-0.838
  body extent -1.49,-1.53 1.51,1.47, height 0.81
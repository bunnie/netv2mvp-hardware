# Altium PCB netv2mvp-dvt1a.PCBDOC (part 5 of 6)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 90 x 100 mm, 6 copper layers (L1, L2, L3, L4, L5, L6), stack 1.542 mm thick; 329 components, 277 nets, 2092 pads, 848 vias.

## Via types
v1: diameter 0.5, hole 0.25, L1 to L6, tented both sides, 789 vias
v2: diameter 0.45, hole 0.25, L1 to L6, tented both sides, 57 vias
v3: diameter 0.5, hole 0.25, L1 to L6, tented top, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
P1.0V: C10F.1 C11F.1 C12F.1 C14P.1 C15P.1 C38F.1 C39F.1 C41F.1 C42F.1 C43F.1 C44F.1 C45F.1 C46F.1 C47F.1 C48F.1 C49F.1 L10P.2 R14P.2 U10F.D6 U10F.D10 U10F.E8 U10F.F7 U10F.F9 U10F.H8 U10F.H10 U10F.J7 U10F.J9 U10F.J11 U10F.K8 U10F.L7 U10F.L11 U10F.M8 U10F.N7 U10F.N11 U10F.P8 U10F.P10 U10F.R7 U10F.R9 U10F.T8 U10F.T10 U10P.A4 | length 47.7
  L1 w0.15: R14P.2@55.85,32.975 55.85,33.125 U10P.A4@57,34.275
  L1 w0.25: U10F.T10@33.879,43.243 v1(34.594,43.243) ; v1(34.578,41.828) U10F.P10@35.293,41.828 ; U10F.N11@35.293,40.414 v1(35.293,41.129) ; v1(35.293,42.528) U10F.R9@35.293,43.243 ; v1@35.293,43.942 v1(35.293,44) U10F.T8@35.293,44.657 ; U10F.L11@36.707,39 v1(36.707,39.715) ; U10F.P8@36.707,43.243 v1(37.422,43.243) ; U10F.R7@36.707,44.657 v1(37.422,44.657) ; U10F.J11@38.121,37.586 v1(38.836,37.586) ; U10F.M8@38.121,41.828 v1(38.121,42.543) ; U10F.N7@38.121,43.243 v1(38.121,43.958) ; v1(39.536,36.871) U10F.H10@39.536,37.586 ; U10F.J9@39.536,39 v1(39.536,39.715) ; U10F.K8@39.536,40.414 v1(39.536,41.129) ; U10F.L7@39.536,41.828 v1(39.536,42.543) ; U10F.H8@40.95,39 v1(40.95,39.715) ; U10F.J7@40.95,40.414 v1(40.95,41.129) ; v1@41.649,34.757 U10F.D10@42.364,34.757 ; v1(41.657,36.164) U10F.F9@41.657,36.879 ; v1@43.071,36.164 U10F.E8@43.071,36.879 ; v1@43.071,37.578 U10F.F7@43.071,38.293 ; v1(44.477,37.586) U10F.D6@45.192,37.586
  L1 w0.5: v1(52.5,37.625) C14P.1@53.825,36.3 ; v1(52.8,36.3) C14P.1@53.825,36.3 ; v1(53.825,37.25) C14P.1@53.825,36.3 ; C14P.1@54.025,36.3 C15P.1@55.525,36.3 ; C15P.1@55.525,36.3 55.675,36.45 55.675,37.45 55.275,37.85 55.275,36.55 C15P.1@55.525,36.3
  L3 w0.15: v1(53.825,37.25) 53.825,35.975 54.35,35.45 54.85,35.45 v1(56.5,33.8)
  L6 w0.25: v1(34.594,43.243) 34.594,43.831 C46F.1@34.45,43.975 35.268,43.975 v1(35.293,44) 35.925,44 C47F.1@36,44.075 ; C39F.1@35,40.65 35,40.836 v1(35.293,41.129) ; v1(35.293,42.528) 35.658,42.528 C42F.1@35.828,42.697 ; v1(36.707,39.715) 36.717,39.725 C45F.1@37.375,39.725 ; v1(38.121,42.543) 38.298,42.543 C43F.1@38.553,42.797 ; C11F.1@38.825,38.325 38.825,37.597 v1(38.836,37.586) ; v1(39.536,39.715) 40.135,39.715 40.25,39.6 40.365,39.715 v1(40.95,39.715) ; v1(39.536,41.129) 39.779,41.372 C41F.1@39.978,41.372 ; C48F.1@41.025,36.225 41.086,36.164 v1(41.657,36.164) ; C12F.1@41.503,34.222 41.649,34.369 v1@41.649,34.757 ; v1@43.071,37.578 C10F.1@43.653,37.578 ; C10F.1@43.775,37.7 C10F.1@43.653,37.578 ; C44F.1@44.925,38.125 44.925,38.033 v1(44.477,37.586) 44.47,37.578 C10F.1@43.653,37.578
  L6 w0.5: v1(52.5,37.625) 52.675,37.625 C49F.1@53.525,38.475 ; v1(53.825,37.25) 53.825,38.175 C49F.1@53.525,38.475 ; v1(54.7,36.3) 53.525,37.475 C49F.1@53.525,38.475
  other v1: 41.66,34.74 43.1,36.164 43.1,37.578
P1.2VTT: C15F.1 C16F.1 C17F.1 C27P.1 C87F.1 C88F.1 R11F.2 U10F.B5 U10F.B7 U10F.B9 U10F.B11 U10F.C4 U10F.C8 U14P.A2 | length 29.9
  L1 w0.25: U10F.B11@43.071,32.636 v1@43.071,33.351 ; U10F.B9@44.485,34.05 v1(44.485,34.765) ; U10F.C8@44.485,35.464 v1(45.2,35.464) ; v1@45.899,34.749 v1(45.899,34.78) U10F.B7@45.899,35.464 ; U10F.B5@47.314,36.879 v1(48.029,36.879) ; U10F.C4@47.314,38.293 v1(48.029,38.293) ; U14P.A2@53.275,32.2 53.725,32.2 ; v1(54.8,32.55) 54.425,32.175 C27P.1@54.175,32.175 ; 53.725,32.2 53.725,32.5 53.45,32.775 v1(53.45,33) v1(54.15,33) 54.175,33.025 C27P.1@54.175,32.175 ; 53.725,32.2 54.15,32.2 C27P.1@54.175,32.175
  L3 w0.25: v1(45.2,35.464) 45.885,34.78 v1(45.899,34.78)
  L3 w0.5: v1(48.029,36.879) v1(48.029,38.293) ; 48.8,38.9 48.636,38.9 v1(48.029,38.293) ; 52.3,33.4 52,33.7 52,36.904 51.8,37.104 51.8,37.892 52.2,38.292 52.2,38.8 51.4,39.6 48.9,39.6 48.029,38.729 v1(48.029,38.293)
  L6 w0.25: R11F.2@42.375,36.275 42.375,36.188 43.581,34.982 44.269,34.982 v1(44.485,34.765) 44.485,34.484 C17F.1@44.151,34.149 ; C15F.1@42.647,32.922 43.071,33.346 v1@43.071,33.351 ; v1(45.2,35.464) 45.9,35.464 C87F.1@46.242,35.122 ; v1(45.899,34.78) C87F.1@46.242,35.122 ; C87F.1@46.253,35.122 C87F.1@46.242,35.122 ; C88F.1@47.578,36.647 47.809,36.879 v1(48.029,36.879) ; v1(48.029,38.293) 48.45,38.714 C16F.1@48.45,38.725
  other v1: 43,33.351
P1.5V_D: C14D.1 C15D.1 C16D.1 C17D.1 C18D.1 C19D.1 C21D.1 C22D.1 C22P.1 C23D.1 C23P.1 C24D.1 C25D.1 C36D.1 C37D.1 C38D.1 C39D.1 C40D.1 C41D.1 C44D.1 C45D.1 C46D.1 C47D.1 C48D.1 C49D.2 C50D.1 C59F.1 C60F.1 C61F.1 C62F.1 C63F.1 C64F.1 C65F.1 C73F.1 C74F.1 C75F.1 C76F.1 C77F.1 C78F.1 C79F.1 L12P.2 R23P.2 R27P.2 U10D.A1 U10D.A8 U10D.B2 U10D.C1 U10D.C9 U10D.D2 U10D.D9 U10D.E9 U10D.F1 U10D.G7 U10D.H2 U10D.H9 U10D.K2 U10D.K8 U10D.N1 U10D.N9 U10D.R1 U10D.R9 U10F.AA7 U10F.AB4 U10F.C1 U10F.F2 U10F.H6 U10F.J3 U10F.M4 U10F.N1 U10F.R5 U10F.T2 U10F.V6 U10F.W3 U11D.A1 U11D.A8 U11D.B2 U11D.C1 U11D.C9 U11D.D2 U11D.D9 U11D.E9 U11D.F1 U11D.G7 U11D.H2 U11D.H9 U11D.K2 U11D.K8 U11D.N1 U11D.N9 U11D.R1 U11D.R9 U12P.A4 U15P.1 | length 124.9
  L1 w0.15: U11D.C9@54.099,52.25 U11D.D9@54.665,52.816 ; v1(57.825,57.025) 57.825,57 58.624,56.201 U11D.K8@58.624,55.644 ; U11D.R1@65.413,54.513 65.413,55.063 66.025,55.675 70.025,55.675 71.475,57.125 72.475,57.125 73.225,57.875 74.025,57.875 U15P.1@74.25,58.1 ; U12P.A4@70.375,66.55 71.525,65.4 R23P.2@71.675,65.4
  L1 w0.2: v2@53.152,50.143 U11D.A8@53.533,50.553 ; U11D.D9@54.665,52.816 v2@55.202,52.816 ; U11D.B2@57.493,47.724 U11D.A1@57.534,46.595 ; v2(58.624,48.319) U11D.D2@58.624,48.856 ; U11D.H2@60.887,51.119 v2(60.887,51.656) ; U11D.K2@62.018,52.25 v2(62.556,52.25) ; C50D.1@66.272,43.053 v1(66.725,43.505)
  L1 w0.25: U10F.AA7@32.464,48.899 v1(32.464,49.614) ; U10F.AB4@33.879,51.728 v1(33.879,52.443) ; U10F.V6@35.293,47.485 v1(35.293,48.2) ; U10F.W3@36.707,50.314 v1(36.707,51.029) ; U10F.R5@38.121,46.071 v1(38.121,46.786) ; U10F.T2@39.536,48.899 v1(39.536,49.6) v1@39.536,49.614 ; v1(40.235,44.657) U10F.M4@40.95,44.657 ; U10F.H6@42.364,40.414 v1(42.364,41.129) ; U10F.N1@42.364,47.485 v1(42.364,48.2) ; v1(43.063,43.243) U10F.J3@43.778,43.243 ; v1(45.892,41.828) U10F.F2@46.607,41.828 ; U10F.C1@49.435,40.414 v1(49.941,40.92) ; C23D.1@61.983,47.689 62.172,47.5 v1(62.6,47.5) ; v1(71.06,55.75) R27P.2@71.775,55.75 ; v1(71.644,56.481) R27P.2@72.15,55.975 ; R27P.2@72.375,55.825 v1(72.881,56.331)
  L1 w0.254: C37D.1@52.331,54.3 52.331,54.018 v1(53.607,52.742) U11D.C9@54.099,52.25 ; C25D.1@53.569,55.114 53.569,55.043 v1(54.738,53.874) U11D.E9@55.23,53.381 v2@55.23,52.844 ; C18D.1@55.195,56.74 56.364,55.571 v1(56.435,55.571) U11D.H9@56.927,55.078 ; U11D.A1@57.493,46.593 v1(57.985,46.101) ; U11D.G7@57.493,53.381 v2(57.493,53.93) ; C16D.1@58.094,59.639 58.094,59.568 v1(59.263,58.399) U11D.N9@59.756,57.907 ; C15D.1@58.554,61.796 58.554,61.584 C45D.1@59.296,60.841 60.403,59.734 v1(60.887,59.734) U11D.R9@60.887,59.038 ; v2@58.624,48.274 U11D.C1@58.624,47.724 v1(59.15,47.199) ; v1(58.7,45.386) 59.155,44.931 C14D.1@59.225,44.931 ; v1(59.85,46.5) C17D.1@60.286,46.063 ; U11D.F1@60.321,49.421 v1(60.814,48.929) ; U11D.N1@64.281,53.381 v1(64.774,52.889) 65.943,51.72 C19D.1@66.014,51.72 ; U11D.R1@65.413,54.513 v1(66.109,54.513) 66.109,54.029 C22D.1@67.216,52.922
  L1 w0.5: v1(66.45,63.025) 66.8,63.375 v1(67.4,63.375) C22P.1@68.35,63.375 ; v1(67.025,62.05) C22P.1@68.35,63.375 ; v1(68.35,62.35) C22P.1@68.35,63.375 ; C22P.1@68.35,63.575 C23P.1@68.35,65.075 ; C23P.1@68.35,65.075 68.1,64.825 66.8,64.825 67.2,65.225 68.2,65.225 C23P.1@68.35,65.075
  L4 w0.15: v1(68.35,62.35) 68.35,63.2 69.225,64.075 69.225,64.425 v1(70.85,66.05)
  L6 w0.15: C74F.1@49.625,39.675 49.625,40.604 v1(49.941,40.92) 50.255,40.92 C65F.1@50.7,40.475 ; v1(57.825,57.025) 58.475,56.375 58.475,55.793 U10D.K2@58.624,55.644
  L6 w0.2: U10D.B2@54.099,51.119 U10D.C1@54.099,52.25 ; U10D.D2@55.23,52.25 v2(55.23,52.787) ; v1(56.469,46.7) U10D.A8@56.927,47.159 ; v2@57.493,53.976 U10D.H2@57.493,54.513 ; v2(59,51.65) 59.531,51.119 U10D.G7@59.756,51.119 ; U10D.H9@61.453,50.553 63.115,48.891 C39D.1@63.115,48.82 ; U10D.K8@62.018,52.25 v2(62.556,52.25) ; U10D.N9@64.264,53.329 U10D.N9@64.281,53.381 65.943,51.72 C41D.1@66.014,51.72 ; U10D.R9@65.413,54.513 v1@65.909,54.513
  L6 w0.25: v1(32.464,49.614) 32.464,48.886 C76F.1@33.053,48.297 ; v1(33.879,52.443) 34.599,51.722 C78F.1@34.599,51.574 ; C61F.1@35.293,47.357 v1(35.293,48.2) ; C75F.1@36.7,51.925 36.7,51.036 v1(36.707,51.029) ; v1(38.121,46.786) 38.125,46.79 C79F.1@38.125,47.675 ; C62F.1@39.447,44.522 39.582,44.657 ; C63F.1@39.525,50.525 39.525,49.611 v1(39.536,49.6) ; C59F.1@41.797,41.247 41.916,41.129 v1(42.364,41.129) ; v1(42.364,48.2) 42.364,47.586 C60F.1@42.428,47.522 ; v1(43.063,43.243) 43.8,43.979 C64F.1@43.8,44.25 ; v1(45.892,41.828) 45.892,42.242 C73F.1@46.153,42.503 ; 39.582,44.657 v1(40.235,44.657) C77F.1@40.235,45.31 ; 39.582,44.657 C77F.1@40.235,45.31 ; C77F.1@40.235,45.31 40.235,45.46 C77F.1@40.25,45.475 40.25,45.325 C77F.1@40.235,45.31
  L6 w0.254: C48D.1@51.306,52.851 51.306,51.919 52.106,51.119 U10D.A1@52.968,51.119 ; C47D.1@52.437,53.982 52.437,53.912 v1(53.607,52.742) U10D.C1@54.099,52.25 ; C46D.1@54.064,55.609 54.738,54.934 v1(54.738,53.874) ; v1@54.811,53.947 U10D.F1@55.796,53.947 ; v1(57.985,46.101) v1(58.7,45.386) ; C24D.1@58.094,59.639 59.263,58.47 v1(59.263,58.399) U10D.N1@59.756,57.907 ; C21D.1@58.554,61.796 58.554,61.584 C36D.1@59.296,60.841 60.403,59.734 v1(60.887,59.734) U10D.R1@60.887,59.038 ; U10D.C9@58.624,47.724 v1(59.85,46.5) ; v2@58.653,48.29 U10D.D9@59.19,48.29 ; U10D.E9@59.756,48.856 v1@60.74,48.856 ; v1(59.85,46.5) 60.132,46.5 C44D.1@60.675,45.957 ; v1(60.814,48.929) 60.814,48.858 C40D.1@61.983,47.689 ; v1(66.109,54.513) 66.109,54.029 C38D.1@67.216,52.922
  L6 w0.3: v1(31.8,52) 31.8,53.2 C49D.2@32.1,53.5 ; v1(32.975,54.125) 32.35,53.5 C49D.2@32.1,53.5 ; v1(33.879,52.443) 33.156,52.443 C49D.2@32.1,53.5
  other v1: 61.975,50.075 51.65,51.625 65.525,52.15 58.912,61.225 68.35,64.25
  other v2: 53.153,50.142
P1.8V: C16P.1 C17P.1 C26F.1 C28F.1 C29F.1 C30F.1 C31F.1 C32F.1 C33F.1 C34F.1 C35F.1 L11P.2 R15P.2 U10F.E12 U10F.H12 U10F.K10 U10F.K12 U10F.M12 U10F.P12 U10F.R11 U11P.A4 | length 31
  L1 w0.15: R15P.2@39.95,21.225 40.1,21.225 40.762,20.563 U11P.A4@41.25,20.075
  L1 w0.25: v1(33.164,40.414) U10F.P12@33.879,40.414 ; v1(33.164,41.828) U10F.R11@33.879,41.828 ; v1(35.293,38.285) U10F.M12@35.293,39 ; U10F.K12@36.707,37.586 v1(37.422,37.586) ; v1(37.406,39) U10F.K10@38.121,39 ; v1(38.121,35.457) U10F.H12@38.121,36.172 ; v1(40.243,33.335) U10F.E12@40.243,34.05
  L1 w0.5: v1(42.925,27.075) 43.3,27.45 C35F.1@44,27.45 44,25.175 v1(44.6,24.575) C16P.1@43.275,23.25 ; C16P.1@43.275,23.05 C17P.1@43.275,21.55 ; v1(43.275,24.275) C16P.1@43.275,23.25 ; v1(44.225,23.25) C16P.1@43.275,23.25 ; C17P.1@43.275,21.55 43.525,21.8 44.825,21.8 44.425,21.4 43.425,21.4 C17P.1@43.275,21.55
  L3 w0.15: v1(40.775,20.575) 42.375,22.175 42.375,23.375 v1(43.275,24.275)
  L6 w0.25: C28F.1@32.325,41.825 33.16,41.825 v1(33.164,41.828) ; v1(33.164,40.414) 33.775,39.803 C26F.1@33.775,39.7 ; v1(35.293,38.285) 35.675,38.667 C34F.1@35.675,38.825 ; C29F.1@36.676,37.149 36.986,37.149 v1(37.422,37.586) 38.089,37.586 C33F.1@38.203,37.472 ; v1(37.406,39) 37.709,38.697 C32F.1@37.947,38.697 ; v1(38.121,35.457) 38.128,35.45 C31F.1@38.775,35.45 ; v1(40.243,33.335) 40.715,33.335 40.728,33.347 C30F.1@41.003,33.347
  other v1: 43.275,22.375 44,25.9
P3.3V: C10C.1 C10H.1 C12H.1 C17C.1 C18C.1 C19C.1 C20C.1 C21C.1 C22C.1 C23C.1 C24P.1 C25P.1 C37P.1 C50F.1 C51F.1 C52F.1 C53F.1 C54F.1 C55F.1 C56F.1 C57F.1 C58F.1 C66F.1 C67F.1 C68F.1 C69F.1 C70F.1 C71F.1 C72F.1 C80F.1 C81F.1 C82F.1 C83F.1 C84F.1 C85F.1 C86F.1 C89F.1 L13P.2 P10C.1 P10F.2 P11H.1 P11H.2 Q16H.1 Q17H.1 Q18H.1 R10C.1 R11C.1 R11H.1 R11H.2 R12C.1 R12F.2 R12H.3 R12H.4 R13F.2 R13H.1 R13H.2 R14F.2 R14H.3 R14H.4 R16C.1 R17C.2 R19H.3 R19H.4 R20C.2 R20P.2 R21C.2 R21H.1 R21H.2 R22C.2 R22H.1 R22H.2 R23C.1 R23H.1 R24H.1 R24P.2 R25H.3 R25H.4 R36H.1 R42H.1 R44H.1 U10C.8 U10F.A17 U10F.AA17 U10F.AB14 U10F.B14 U10F.C21 U10F.D18 U10F.E15 U10F.F12 U10F.F22 U10F.G19 U10F.H16 U10F.J13 U10F.K20 U10F.L17 U10F.M14 U10F.N21 U10F.P18 U10F.R15 U10F.T12 U10F.T22 U10F.U8 U10F.U11 U10F.U19 U10F.V16 U10F.W13 U10F.Y10 U10F.Y20 U10H.14 U11C.3 U11C.13 U11C.14 U11C.21 U11C.30 U11C.48 U11F.1 U11F.4 U13P.A4 U15P.10 | length 145
  L1 w0.15: U13P.A4@85.875,66.975 86.362,66.487 87.025,65.825 R24P.2@87.175,65.825
  L1 w0.2: v1(32.464,43.958) 32.483,43.958 33.889,45.364 U10F.U8@34.586,45.364 ; v1(38.828,33.343) 39.536,34.051 U10F.F12@39.536,34.757 ; C37P.1@71.528,58.922 72.355,59.75 72.6,59.75 U15P.10@72.878,59.472
  L1 w0.25: v1(21.475,71.1) R12C.1@22.55,71.1 ; v1(23.264,39) U10F.Y20@23.979,39 ; v1(25.393,34.042) U10F.T22@25.393,34.757 ; U10F.AA17@25.393,41.828 v1(25.393,42.543) ; R11C.1@26.375,60.525 26.375,62.17 U10C.8@26.405,62.2 27.225,62.2 C10C.1@27.9,62.875 v1(28.7,62.875) ; R10C.1@26.4,71.75 v1(26.4,72.325) ; U10F.U19@26.808,37.586 v1(26.808,38.301) ; U10F.AB14@26.808,44.657 v1(26.808,45.372) ; v1(28.222,32.628) U10F.N21@28.222,33.343 ; U10F.V16@28.222,40.414 v1(28.222,41.129) ; v1(29.636,35.457) U10F.P18@29.636,36.172 ; U10F.W13@29.636,43.243 v1(29.636,43.958) ; v1(30.335,46.071) U10F.Y10@31.05,46.071 ; U10F.K20@31.05,31.929 v1(31.765,31.929) ; U10F.R15@31.05,39 v1(31.05,39.715) ; v1(31.749,34.757) U10F.L17@32.464,34.757 ; v1(32.464,26.971) U10F.F22@32.464,27.686 ; U10F.T12@32.464,41.828 v1(32.464,42.543) ; U10F.U11@32.464,43.243 v1(32.464,43.958) ; v1(33.164,37.586) U10F.M14@33.879,37.586 ; v1(33.879,29.8) U10F.G19@33.879,30.515 ; v1(34.578,26.272) U10F.C21@35.293,26.272 ; v1(34.578,33.343) U10F.H16@35.293,33.343 ; U10F.D18@36.707,29.101 v1(37.422,29.101) ; v1(36.707,35.457) U10F.J13@36.707,36.172 ; v1(38.121,31.214) U10F.E15@38.121,31.929 ; U10F.A17@39.536,27.686 v1(40.041,27.181) ; v1(40.95,29.8) U10F.B14@40.95,30.515 ; R44H.1@40.975,72.125 40.725,72.375 Q18H.1@40.725,73.85 v1(41.425,73.85) ; R42H.1@41.85,64.8 41.55,65.1 Q17H.1@41.55,66.525 v1(42.3,66.525) ; v1(53.8,29.3) R20P.2@53.8,30.175 v1(54.725,30.175) ; R22C.2@62.25,38.375 61.4,38.375 61.025,38.75 61.025,39.35 61.275,39.6 R21C.2@62.25,39.6 ; v1(62.475,31.675) 63.525,31.675 C17C.1@63.55,31.7 63.55,31.75 C19C.1@64.8,33 65.075,33 65.55,33.475 U11C.48@66.5,33.475 ; v1(64.775,77.225) C12H.1@64.775,76.475 64.775,75.525 R36H.1@65.125,75.175 65.35,74.95 Q16H.1@65.35,73.4 ; U11C.30@69.3,42.775 69.3,43.875 69.55,44.125 69.55,44.65 v1(69.9,45) ; v1(71.022,59.428) C37P.1@71.528,58.922 ; v1(72.95,68.225) R24H.1@72.95,69.2 ; C18C.1@73.25,45.1 73.8,44.55 U11C.21@73.8,42.775 ; R16C.1@73.425,47.975 v1(74.525,47.975) ; v1(76.625,68.225) R23H.1@76.625,69.2 ; U11C.3@77.6,34.475 78.65,34.475 79.075,34.05 C20C.1@79.35,34.05 v1(79.35,33.45) ; U11C.13@77.6,39.475 79.025,39.475 79.3,39.75 C23C.1@79.3,40.3 ; U11C.14@77.6,39.975 78.975,39.975 C23C.1@79.3,40.3 ; v1(81.75,40.75) C22C.1@80.6,40.75 ; R23C.1@82,49.95 v1(82,51.25) ; R20C.2@84.025,33.975 84.125,33.875 v1(85,33.875) ; C23C.1@79.3,40.3 80.15,40.3 C22C.1@80.6,40.75 ; C23C.1@79.3,40.3 79.5,40.1 80.25,40.1 80.6,40.45 C22C.1@80.6,40.75
  L1 w0.5: v1(82.525,62.475) C25P.1@83.85,63.8 ; v1(82.9,63.8) C25P.1@83.85,63.8 ; v1(83.85,62.775) C25P.1@83.85,63.8 ; C25P.1@83.85,64 v1(83.85,64.675) C24P.1@83.85,65.5 ; C24P.1@83.85,65.5 83.6,65.25 82.3,65.25 82.7,65.65 83.7,65.65 C24P.1@83.85,65.5
  L4 w0.15: v1(83.85,62.775) 83.85,63.525 84.775,64.45 84.775,64.9 v1(86.35,66.475)
  L6 w0.1: U11F.1@37.656,32.535 37.656,31.679 v1(38.121,31.214)
  L6 w0.2: C58F.1@31.65,43.975 C58F.1@31.667,43.958
  L6 w0.25: v1(20.2,63) 21.35,63 21.575,62.775 U10H.14@22.7,62.775 ; R22H.1@22.55,44.8 22.55,45.31 22.73,45.49 23.2,45.49 R22H.2@23.2,44.8 ; R19H.4@22.887,36.853 23.26,36.48 23.45,36.48 23.72,36.75 23.72,36.939 R19H.3@23.347,37.313 23.347,38.917 v1(23.264,39) 23.94,39 C81F.1@24.133,38.807 ; R21H.1@23.95,41.63 24.22,41.9 24.64,41.9 24.89,41.65 ; R21H.2@24.41,41.17 24.89,41.65 ; C83F.1@24.6,42.525 25.375,42.525 v1(25.393,42.543) 25.393,42.154 24.89,41.65 ; v1(24.92,30.38) 25.21,30.09 R13H.2@25.96,30.09 ; v1(25.393,34.042) 25.393,34.918 C84F.1@25.676,35.201 ; R25H.4@25.55,37.31 25.55,36.84 25.75,36.64 25.94,36.64 26.2,36.9 R25H.3@26.2,37.31 26.5,37.31 26.808,37.618 v1@26.808,38.192 ; R13H.1@25.96,29.44 25.96,28.98 v1(26.2,28.74) ; v1(26.808,38.301) v1@26.808,38.192 ; C51F.1@27.45,37.55 v1@26.808,38.192 ; v1(28.222,32.628) 28.694,33.1 C82F.1@28.9,33.1 ; v1(28.222,41.129) 29.229,41.129 R13F.2@29.3,41.2 ; v1(29.636,35.457) 30.107,35.457 C53F.1@30.275,35.625 ; R11H.2@29.84,28.37 29.54,28.069 29.54,27.78 30,27.32 30.29,27.32 ; R11H.1@30.3,27.91 30.3,27.33 30.29,27.32 ; C57F.1@31.65,34.125 C57F.1@31.733,34.042 ; C58F.1@31.667,43.958 v1(32.464,43.958) ; C57F.1@31.75,34.063 v1@31.75,34.794 ; v1(31.765,31.929) 32.15,32.314 C52F.1@32.15,32.425 ; C66F.1@31.978,42.728 32.162,42.543 v1(32.464,42.543) ; C71F.1@32.65,38.125 33.189,37.586 v1(33.164,37.586) 33.889,37.586 R14F.2@34.701,36.774 34.701,36.502 R12F.2@33.949,35.751 ; C68F.1@33.2,27.675 33.168,27.675 v1(32.464,26.971) 32.183,26.69 C56F.1@31.42,26.69 31.42,26.94 31.04,27.32 30.29,27.32 ; v1(33.879,29.8) 34.3,29.8 ; R14H.4@33.91,33.24 34.475,33.24 v1(34.578,33.343) ; R14H.3@33.91,33.89 34.28,33.89 34.578,33.592 v1(34.578,33.343) ; R12H.4@34.27,30.51 34.27,29.83 34.3,29.8 ; R12H.3@34.27,31.16 34.6,31.16 34.83,30.93 34.83,29.53 34.826,29.526 34.552,29.8 34.3,29.8 ; v1(34.578,26.272) 34.822,26.272 C54F.1@35.25,26.7 ; C55F.1@35.2,33.725 34.818,33.343 v1(34.578,33.343) ; U11F.4@36.56,33.631 36.56,34.635 36.725,34.8 36.725,35.439 v1(36.707,35.457) ; v1(37.422,29.101) 37.8,28.723 C69F.1@37.8,28.475 ; v1(38.121,31.214) 38.111,31.214 C85F.1@38.525,30.8 ; C80F.1@38.722,32.753 38.828,32.858 v1(38.828,33.343) C70F.1@38.828,34.003 ; C72F.1@39.099,26.899 39.76,26.899 v1(40.041,27.181) ; v1(40.95,29.8) C67F.1@41.428,30.278 ; v1(72.975,38.5) R17C.2@74.1,38.5 v1(74.1,39.525)
  L6 w0.5: v1(30.325,23.025) 30.475,23.025 C50F.1@31.525,24.075 C50F.1@31.42,24.18 ; v1(30.475,24.825) 30.775,24.825 C50F.1@31.42,24.18 ; C56F.1@31.42,26.69 C50F.1@31.42,24.18
  other v1: 31.425,25.5 61.025,39.05 73.8,44.275 23.46,45.75 71.98,59.375
P3V_MTT: C26P.1 R20P.1 U14P.A1 | length 3.4
  L1 w0.25: R20P.1@52.1,30.175 51.5,30.775 51.5,31.7 51.875,32.075 C26P.1@52.025,32.075 52.15,32.2 U14P.A1@52.925,32.2
P3V_VTT: C29P.1 R27P.1 U15P.2 | length 3.9
  L1 w0.2: R27P.1@73.501,56.951 C29P.1@75.443,56.951 ; U15P.2@74.533,58.383 74.9,58.016 74.9,57.494 C29P.1@75.443,56.951 ; C29P.1@75.559,56.834 C29P.1@75.443,56.951
P5.0V: C34P.2 C35P.2 D11P.1 F10H.1 F11H.1 L14P.2 P11C.1 P11C.3 Q10H.2 R10P.1 R11P.1 R16H.1 R18P.1 R19P.1 R22P.2 R28P.1 R29P.2 R41H.1 R43H.1 | length 120.1
  L1 w0.1: v1(82.875,72.15) 83.975,72.15 84.525,72.7 86.725,72.7 87.225,72.2 R22P.2@87.225,70.8
  L1 w0.2: D11P.1@2,69.95 7.375,69.95 8,69.325 ; v1(19.425,80.325) R29P.2@19.425,81.425 ; R43H.1@42.275,77.4 v1(43.15,77.4) ; R41H.1@43.075,70.1 v1(43.075,70.9)
  L1 w0.3: v1(11.85,29.975) 12.5,30.625 R16H.1@12.5,30.7 12.85,30.35 Q10H.2@14.125,30.35 ; v1(67.25,73.675) R18P.1@68.375,73.675 ; v1(68.375,74.775) R18P.1@68.375,73.675 ; v1(69.45,73.675) R18P.1@68.375,73.675 ; v1(79.65,69.425) R19P.1@80.725,69.425 ; v1(80.725,68.275) R19P.1@80.725,69.425 ; v1(82.875,72.15) 82.55,72.15 R28P.1@81.85,71.45 80.725,70.325 R19P.1@80.725,69.425
  L1 w0.5: v1(47,17.625) 46.425,17.05 R11P.1@46.425,16.125 ; v1(47.975,16.925) 47.175,16.125 R11P.1@46.425,16.125 ; v1(49.55,15.25) 47.025,15.25 46.425,15.85 R11P.1@46.425,16.125 ; v1(59.125,41.05) 59.125,40.2 R10P.1@59.9,39.425 ; v1(60.075,41.075) 60.075,39.6 R10P.1@59.9,39.425 ; v1(61.15,41.1) 61.15,40.625 59.95,39.425 R10P.1@59.9,39.425
  L3 w0.2: v1(11.05,67.8) 11.05,70.175 12.825,71.95 12.825,75.875 17.275,80.325 v1(19.425,80.325)
  L3 w0.8: v1(11.35,53.45) 10.075,52.175 10.075,43.775 8.95,42.65 7.45,42.65 6.6,41.8 6.6,40.125 10.725,36 10.725,34.4 11.85,33.275 v1(11.85,29.975) ; 12.275,54.275 11.45,53.45 v1(12.425,53.45) 12.425,63.925 v1(9.45,66.9) 9.45,67.25 ; 9.45,67.25 9.45,67.325 v1(8.95,67.825) 9.975,67.825 v1(10,67.8) 9.45,67.25
  L4 w1: 83.65,68.875 85.1,67.425
  L6 w0.5: v1(11.35,53.45) v1(12.425,53.45) 13.2,53.45 14.05,52.6 16.4,52.6 17,53.2 17,53.7 17.7,54.4 18,54.4 F10H.1@18.3,54.7 ; F11H.1@36.9,69.45 v1(40.5,69.45)
  other v1: 82.25,46.15 83.4,46.15 82.825,46.875 83.675,47.375 82.45,47.675 11.625,66.9 12.175,67.8 80.875,70.45
P5V_1: C10P.1 C11P.1 R10P.2 R12P.2 U10P.A2 U10P.D1 U10P.D2 U10P.E1 U10P.E2 | length 21.5
  L1 w0.1: U10P.A2@57.8,34.275 57.8,33.7 58.55,32.95 58.55,31.375 59.2,30.725 60.075,30.725 60.875,31.525 R12P.2@60.875,32.925 62.075,32.925 62.7,33.55 62.7,35.5 61.925,36.275 C10P.1@60.95,36.275
  L1 w0.25: U10P.D2@57.8,35.475 U10P.D1@58.2,35.475 58.525,35.475 ; U10P.E2@57.8,35.875 U10P.E1@58.2,35.875 58.825,35.875 ; 58.525,35.475 58.85,35.475 59.075,35.7 ; 58.525,35.475 58.55,35.5 58.55,35.725 58.575,35.7 59.075,35.7 ; 58.825,35.875 C11P.1@59.25,35.875 ; 58.825,35.875 59.025,36.075 C11P.1@59.45,36.075 C11P.1@59.25,35.875 ; 59.075,35.7 C11P.1@59.25,35.875
  L1 w0.5: C11P.1@59.45,36.075 C10P.1@60.55,36.075 ; R10P.2@59.9,37.725 59.9,37.6 60.95,36.55 C10P.1@60.95,36.275
P5V_1.5: C18P.1 C19P.1 R18P.2 R21P.1 U12P.D1 U12P.D2 U12P.E1 U12P.E2 | length 14.1
  L1 w0.1: R18P.2@68.375,71.95 69.3,71.95 70.325,72.975 71.925,72.975 72.075,72.825 72.075,71.4 71.75,71.075 R21P.1@71.75,70.4
  L1 w0.25: U12P.E2@68.775,67.35 68.775,68.375 ; U12P.D2@69.175,67.35 U12P.D1@69.175,67.75 69.175,68.075 ; 68.775,68.375 68.575,68.575 C19P.1@68.575,69 C19P.1@68.775,68.8 ; 68.775,68.375 C19P.1@68.775,68.8 ; C19P.1@68.775,68.8 68.95,68.625 ; 68.95,68.625 68.95,68.125 68.925,68.1 69.15,68.1 69.175,68.075 ; 68.95,68.625 69.175,68.4 69.175,68.075
  L1 w0.5: C18P.1@68.375,70.5 R18P.2@68.375,71.95 ; C19P.1@68.575,69 C18P.1@68.575,70.1
P5V_1.8: C12P.1 C13P.1 R11P.2 R13P.2 U11P.D1 U11P.D2 U11P.E1 U11P.E2 | length 8.6
  L1 w0.2: R13P.2@44.575,14.775 R11P.2@44.575,16
  L1 w0.25: U11P.D2@42.45,19.275 42.45,18.55 ; U11P.E2@42.85,19.275 42.85,18.25 ; 42.45,18.55 42.475,18.525 42.7,18.525 42.675,18.5 42.675,18 ; 42.45,18.55 42.45,18.225 42.675,18 ; 42.675,18 C13P.1@42.85,17.825 ; C13P.1@42.85,17.825 43.05,17.625 43.05,18.05 42.85,18.25 ; C13P.1@42.85,17.825 42.85,18.25
  L1 w0.5: C12P.1@43.05,16.525 C13P.1@43.05,17.625 ; C12P.1@43.25,16.125 R11P.2@44.7,16.125
P5V_3.3: C20P.1 C21P.1 R19P.2 U13P.D1 U13P.D2 U13P.E1 U13P.E2 | length 8
  L1 w0.25: U13P.E2@84.275,67.775 U13P.E1@84.275,68.175 84.275,68.8 ; U13P.D2@84.675,67.775 84.675,68.5 ; 84.275,68.8 84.075,69 C21P.1@84.075,69.425 C21P.1@84.275,69.225 ; 84.275,68.8 C21P.1@84.275,69.225 ; C21P.1@84.275,69.225 84.45,69.05 ; 84.45,69.05 84.45,68.55 84.425,68.525 84.65,68.525 84.675,68.5 ; 84.45,69.05 84.675,68.825 84.675,68.5
  L1 w0.4: R19P.2@82.425,69.425 82.425,69.45 C20P.1@83.875,70.9
  L1 w0.5: C21P.1@84.075,69.425 C20P.1@84.075,70.525
P12V: C32P.2 C33P.1 C38P.1 D10P.1 JP10P.1 P13H.A2 P13H.A3 P13H.B1 P13H.B2 P13H.B3 U16P.3 | length 197
  L1 w0.4: P13H.B1@45.7,3.5 45.7,6.1 46.325,6.725 v1(46.65,6.725) P13H.B2@46.65,3.5 ; P13H.B3@47.65,3.5 v1(47.65,6.725) v1(47.65,7.7)
  L1 w1: JP10P.1@3.375,86.875 JP10P.1@9.475,86.875 17.375,86.875 C38P.1@17.5,86.75 19.525,86.75 21.925,84.35 21.925,79.775 20.1,77.95 20.1,71.725 C32P.2@17.775,69.4 17.775,70.675 C33P.1@16.825,71.625 U16P.3@16.825,74.745
  L6 w0.4: 46.425,7.15 45.975,6.7 v1(45.975,6.4) ; P13H.A2@46.65,3.5 46.65,6.15 ; 47.175,6.825 46.75,6.4 46.65,6.4 ; P13H.A3@47.65,3.5 47.65,6.125 ; v1(47.65,7.7) v1(47.65,6.725) 47.65,6.125 ; v1(45.975,6.4) 46.4,6.4 ; v1(45.975,6.4) 46.3,6.725 v1(46.65,6.725) 46.65,6.4 ; 46.4,6.4 46.65,6.15 ; 46.4,6.4 46.65,6.4 ; 46.65,6.15 46.675,6.125 47.65,6.125 ; 46.65,6.15 46.65,6.4
  L6 w1.5: 6.25,41.15 6.25,40.325 ; v1(21.7,84.625) 19.8,86.525 14.15,86.525 11.075,83.45 11.075,80.125 6.55,75.6 6.55,70.5 7.65,69.4 7.65,66.45 7.95,66.15 7.95,59.575 6.25,57.875 6.25,40.325 ; 47.175,6.825 47.175,8.225 48,9.05 48,14.55 43.05,19.5 41.256,19.5 41.231,19.475 40.3,19.475 39.775,19.7 19.55,19.7 16.875,22.375 11.275,22.375 10.2,23.45 10.2,28 8.975,29.225 7.6,29.225 6.375,30.45 6.375,32.375 9.675,35.675 9.675,37.725 8.625,38.775 7.8,38.775 6.25,40.325
  other v1: 21.1,85.225 20.475,85.8 19.85,86.35
PCICLK_N: C23F.1 U10F.E10 | length 9.1
  L1 w0.1: v1(40.961,35.464) 40.961,35.586 41.225,35.85 41.4,35.85 41.657,35.593 U10F.E10@41.657,35.464
  L6 w0.1: v1(40.961,35.464) 40.778,35.647 40.578,35.647 40.44,35.51 40.44,35.41 40.85,35 41.067,35 41.467,35.4 41.855,35.4 44.765,32.49 44.925,32.33 44.925,32.29 45.478,31.737 C23F.1@45.796,31.737
PCICLK_P: C21F.1 U10F.F10 | length 9.1
  L1 w0.1: v1@40.25,36.175 v1(40.253,36.172) U10F.F10@40.95,36.172
  L6 w0.1: v1(40.253,36.172) 40.5,35.925 40.5,35.852 40.2,35.552 40.2,35.367 40.817,34.75 41.1,34.75 41.55,35.2 41.772,35.2 44.725,32.247 44.725,32.208 45.016,31.916 45.337,31.596 C21F.1@45.337,31.278
PER0_N: C25F.1 P13H.A17 | length 37.6
  L6 w0.101: C25F.1@49.283,33.128 49.283,32.851 50.225,31.909 50.225,30.25 47.83,27.855 47.83,21.929 63.251,6.509 63.251,6.05 63.65,5.65 P13H.A17@63.65,3.5
PER0_P: C24F.1 P13H.A16 | length 37.4
  L6 w0.101: C24F.1@48.824,32.668 49.182,32.668 50.024,31.826 50.024,30.333 47.629,27.938 47.629,21.846 63.05,6.425 63.05,6.05 62.65,5.65 P13H.A16@62.65,3.5
PER1_N: C36F.1 P13H.A22 | length 42
  L6 w0.101: C36F.1@50.476,33.791 50.476,33.484 51.025,32.934 51.025,29.041 49.103,27.119 49.103,22.456 61.983,9.576 66.458,9.576 68.251,7.784 68.251,6.05 68.65,5.65 P13H.A22@68.65,3.5
PER1_P: C27F.1 P13H.A21 | length 41.9
  L6 w0.101: C27F.1@50.016,33.331 50.344,33.331 50.824,32.851 50.824,29.124 48.902,27.202 48.902,22.373 61.9,9.375 66.375,9.375 68.05,7.701 68.05,6.05 67.65,5.65 P13H.A21@67.65,3.5
PER2_N: C40F.1 P13H.A26 | length 45.2
  L1 w0.101: v1(49.275,31.55) 49.625,31.55 50.256,30.919 50.256,27.154 v1(50.46,26.95)
  L6 w0.101: C40F.1@47.652,32.903 47.652,32.61 48.912,31.35 v1@49.275,31.35 ; v1@50.252,26.925 50.252,22.932 61.833,11.351 69.983,11.351 72.251,9.084 72.251,6.05 72.65,5.65 P13H.A26@72.65,3.5
PER2_P: C37F.1 P13H.A25 | length 45.2
  L1 w0.101: v1(49.275,30.94) 49.275,31.149 49.484,31.149 49.485,31.15 49.741,31.15 50.054,30.836 50.054,27.154 v1(49.85,26.95)
  L6 w0.101: C37F.1@47.192,32.443 47.535,32.443 48.829,31.149 v1@49.275,31.149 ; v1@50.051,26.925 50.051,22.849 61.75,11.15 69.9,11.15 72.05,9 72.05,6.05 71.65,5.65 P13H.A25@71.65,3.5
PER3_N: C22F.1 P13H.A30 | length 48.4
  L6 w0.101: C22F.1@50.904,35.219 50.904,34.931 51.975,33.859 51.975,23.009 62.083,12.901 72.358,12.901 76.251,9.009 76.251,6.05 76.65,5.65 P13H.A30@76.65,3.5
PER3_P: C20F.1 P13H.A29 | length 48.3
  L6 w0.101: C20F.1@50.444,34.759 50.791,34.759 51.774,33.776 51.774,22.926 62,12.7 72.275,12.7 76.05,8.925 76.05,6.05 75.65,5.65 P13H.A29@75.65,3.5
PERC0_N: C25F.2 U10F.C5 | length 6.6
  L1 w0.1: U10F.C5@46.607,37.586 v1(47.303,37.586)
  L6 w0.1: v1(47.303,37.586) 47.039,37.85 46.89,37.85 46.626,37.586 46.626,35.949 47.125,35.45 47.125,35.15 48.284,33.991 48.284,33.809 48.47,33.623 C25F.2@48.788,33.623
PERC0_P: C24F.2 U10F.D5 | length 6.7
  L1 w0.1: U10F.D5@45.899,38.293 v1(46.596,38.293)
  L6 w0.1: v1(46.596,38.293) 46.596,37.839 46.426,37.669 46.426,35.866 46.925,35.367 46.925,35.067 48.084,33.908 48.084,33.726 48.329,33.482 C24F.2@48.329,33.163
PERC1_N: C36F.2 U10F.A6 | length 4.5
  L1 w0.1: U10F.A6@47.314,35.464 v1(48.01,35.464)
  L6 w0.1: v1(48.01,35.464) 48.321,35.775 48.567,35.775 48.57,35.772 48.603,35.772 48.775,35.6 48.775,35.3 48.375,34.9 48.375,34.75 48.525,34.6 49.35,34.6 49.664,34.286 C36F.2@49.981,34.286
PERC1_P: C27F.2 U10F.B6 | length 4.4
  L1 w0.1: U10F.B6@46.607,36.172 v1(47.303,36.172)
  L6 w0.1: v1(47.303,36.172) 47.6,35.874 47.6,35.242 48.442,34.4 49.267,34.4 49.521,34.146 C27F.2@49.521,33.826
PERC2_N: C40F.2 U10F.C7 | length 5.9
  L1 w0.1: U10F.C7@45.192,36.172 v1(45.889,36.172)
  L6 w0.1: v1(45.889,36.172) 45.635,36.425 45.35,36.425 44.775,35.85 44.775,35.324 45.9,34.2 46.062,34.2 46.864,33.397 C40F.2@47.157,33.397
PERC2_P: C37F.2 U10F.D7 | length 5.9
  L1 w0.1: U10F.D7@44.485,36.879 v1(45.182,36.879)
  L6 w0.1: v1(45.182,36.879) 45.182,36.539 44.575,35.933 44.575,35.241 45.817,34 45.979,34 46.697,33.281 C37F.2@46.697,32.938
PERC3_N: C22F.2 U10F.A4 | length 3.5
  L1 w0.1: U10F.A4@48.728,36.879 v1(49.424,36.879)
  L6 w0.1: v1(49.424,36.879) 49.746,37.2 49.9,37.2 50.125,36.975 50.125,36.725 49.7,36.3 49.7,36.104 50.09,35.714 C22F.2@50.409,35.714
PERC3_P: C20F.2 U10F.B4 | length 3.5
  L1 w0.1: U10F.B4@48.021,37.586 v1(48.717,37.586)
  L6 w0.1: v1(48.717,37.586) 49.025,37.278 49.025,37.045 ; 49.024,36.713 49.024,37.044 ; 49.025,36.712 49.025,36.496 49.949,35.572 C20F.2@49.949,35.254
PERST#: P13H.A11 U10F.E18 | length 36.6
  L1 w0.1: U10F.E18@36,29.808 v1(36.7,29.808)
  L6 w0.1: v1(36.7,29.808) 36.7,29.125 37.2,28.625 37.2,28.375 37.575,28 40.625,28 41.775,26.85 41.775,25.175 42.35,24.6 42.35,24.4 44.65,22.1 44.65,21.975 51.5,15.125 51.5,13.2 v1(55.65,9.05) P13H.A11@55.65,3.5
PET0_N: P13H.B15 U10F.C11 | length 38.9
  L1 w0.1: U10F.C11@42.364,33.343 42.15,33.129 42.15,32.991 42.95,32.191 43.234,32.191 43.35,32.075 43.35,31.791 44.291,30.85 44.475,30.85 44.6,30.975 44.8,30.975 44.925,30.85 44.925,30.7 44.759,30.534 44.759,30.384 45,30.142 45.233,30.142 45.409,29.966 45.409,29.734 45.692,29.45
  L1 w0.101: 45.692,29.45 45.692,25.283 61.251,9.724 61.251,6.05 61.65,5.65 P13H.B15@61.65,3.5
PET0_P: P13H.B14 U10F.D11 | length 38.9
  L1 w0.1: U10F.D11@41.657,34.05 41.95,33.757 41.95,32.909 44.554,30.304
  L1 w0.101: 44.433,30.425 45.491,29.367 45.491,25.2 61.05,9.641 61.05,6.05 60.65,5.65 P13H.B14@60.65,3.5
PET1_N: P13H.B20 U10F.A10 | length 39.8
  L1 w0.1: U10F.A10@44.485,32.636 44.275,32.426 44.275,32.3 44.5,32.075 44.75,32.075 44.875,32.2 45.1,32.2 45.25,32.05 45.25,31.8 45.1,31.65 45.1,31.475 45.45,31.125 45.6,31.125 45.875,30.85 45.875,30.7
  L1 w0.101: 45.875,30.7 46.947,29.628 46.947,25.728 63.024,9.651 64.058,9.651 66.25,7.459 66.25,6.05 66.65,5.65 P13H.B20@66.65,3.5
PET1_P: P13H.B19 U10F.B10 | length 39.8
  L1 w0.1: U10F.B10@43.778,33.343 44.075,33.046 44.075,32.217 45.325,30.967
  L1 w0.101: 45.325,30.967 46.746,29.545 46.746,25.644 62.941,9.45 63.975,9.45 66.049,7.376 66.049,6.05 65.65,5.65 P13H.B19@65.65,3.5
PET2_N: P13H.B24 U10F.C9 | length 45.5
  L1 w0.1: U10F.C9@43.778,34.757 43.575,34.554 43.575,34.395 44.32,33.65 44.7,33.65 44.792,33.558 44.792,33.177 45.532,32.438 45.537,32.438 45.7,32.275 45.925,32.275 46.075,32.425 46.275,32.425 46.4,32.3 46.4,32.1 46.225,31.925 46.225,31.75 46.275,31.7
  L1 w0.101: 46.275,31.7 46.501,31.475 46.675,31.475 46.875,31.275 46.875,31.1 48.267,29.709 48.267,26.099 63.04,11.326 66.358,11.326 70.251,7.434 70.251,6.05 70.65,5.65 P13H.B24@70.65,3.5
PET2_P: P13H.B23 U10F.D9 | length 45.5
  L1 w0.1: U10F.D9@43.071,35.464 43.375,35.161 43.375,34.312 45.449,32.238 45.455,32.238 46.134,31.559
  L1 w0.101: 45.958,31.733 48.066,29.626 48.066,26.016 62.956,11.125 66.275,11.125 70.05,7.35 70.05,6.05 69.65,5.65 P13H.B23@69.65,3.5
PET3_N: P13H.B28 U10F.A8 | length 47
  L1 w0.1: U10F.A8@45.899,34.05 45.675,33.826 45.675,33.725 45.95,33.45 46.175,33.45 46.325,33.6 46.55,33.6 46.7,33.45 46.7,33.25 46.55,33.1 46.55,32.85 46.775,32.625
  L1 w0.101: 46.65,32.75 49.369,30.032 49.369,26.556 63.049,12.876 68.983,12.876 74.251,7.609 74.251,6.05 74.65,5.65 P13H.B28@74.65,3.5
PET3_P: P13H.B27 U10F.B8 | length 47
  L1 w0.1: U10F.B8@45.192,34.757 45.475,34.475 45.475,33.642 46.634,32.484
  L1 w0.101: 46.558,32.558 49.168,29.948 49.168,26.473 62.966,12.675 68.9,12.675 74.05,7.525 74.05,6.05 73.65,5.65 P13H.B27@73.65,3.5
PGOOD_P1.0V: R12P.1 U10P.A1 U11P.A2 | length 45.5
  L1 w0.1: v1(38,15.7) 38,18.4 38.4,18.8 40.275,18.8 40.75,19.275 U11P.A2@41.25,19.275 ; U10P.A1@58.2,34.275 59.55,32.925 R12P.1@59.675,32.925 v1(59.675,31.275)
  L3 w0.1: v1(38,15.7) 38.5,16.2 39.9,16.2 40.5,15.6 44.1,15.6 45.8,13.9 47.1,13.9 48.9,15.7 48.9,23.325 51.9,26.325 51.9,27.975 52.725,28.8 57.2,28.8 v1(59.675,31.275)
PGOOD_P1.8V: R13P.1 U11P.A1 U12P.A2 U13P.A2 U14P.B1 U15P.7 U15P.9 | length 125.2
  L1 w0.1: U11P.A1@41.25,18.875 40.225,17.85 40.225,15.75 40.225,14.925 40.825,14.325 42.925,14.325 R13P.1@43.375,14.775 43.4,14.775 43.975,14.2 45.65,14.2 v1(46.025,14.575) ; U14P.B1@52.925,31.85 52.925,31.75 53.6,31.075 54.475,31.075 55.225,30.325 v1(57.275,30.325) ; U12P.A2@70.375,67.35 71,67.35 v1(71.425,67.775) ; v1(71.763,60.763) 72.275,60.763 ; U15P.9@73.161,59.755 73.161,59.764 72.75,60.175 72.65,60.175 72.275,60.55 72.275,60.763 ; U15P.7@73.727,60.32 73.3,60.747 73.3,60.975 73.125,61.15 72.45,61.15 72.275,60.975 72.275,60.763 ; U13P.A2@85.875,67.775 86.55,67.775 v1(86.925,68.15)
  L3 w0.1: v1(46.025,14.575) 46.025,24.95 51.275,30.2 53.225,30.2 53.75,30.725 55.025,30.725 55.425,30.325 v1(57.275,30.325) 57.275,41.925 59.325,43.975 64.225,43.975 65.15,44.9 67.175,44.9 68.3,46.025 69.4,46.025 73.725,50.35 73.725,51.925 76.025,54.225 76.025,56 77.2,57.175 77.2,59.775 75.7,61.275 72.275,61.275 v1(71.763,60.763) ; v1(71.425,67.775) 71.775,67.425 73.5,67.425 73.825,67.75 75.85,67.75 76.2,67.4 86.175,67.4 v1(86.925,68.15)
  L4 w0.1: v1(71.425,67.775) 71.425,67.725 76.05,63.1 76.05,61.5 75.6,61.05 74.6,61.05 73.475,59.925 72.6,59.925 v1(71.763,60.763)
PRSNT: P13H.A1 R37H.2 R38H.2 | length 41.1
  L1 w0.1: R37H.2@63.625,16.1 R38H.2@77.65,16.1
  L4 w0.1: v1(46.325,9.4) 47.1,9.4 53.825,16.125 v1(64.9,16.125)
  L6 w0.1: P13H.A1@45.65,4 45.55,4.1 45.55,8.625 v1(46.325,9.4)
PRSNT_X1: P13H.B17 R37H.1 | length 12.7
  L1 w0.1: R37H.1@63.625,14.9 v1(64.875,14.9) ; P13H.B17@63.65,4 v1(63.65,7.825)
  L3 w0.1: v1(63.65,7.825) 63.65,13.675 v1(64.875,14.9)
PRSNT_X4: P13H.B31 R38H.1 | length 10.9
  L1 w0.1: P13H.B31@77.65,4 R38H.1@77.65,14.9
REFCLK_N: C23F.2 P13H.A14 | length 33.7
  L6 w0.101: C23F.2@46.291,31.242 46.291,30.918 46.575,30.634 46.575,21.409 60.251,7.734 60.251,6.05 60.65,5.65 P13H.A14@60.65,3.5
REFCLK_P: C21F.2 P13H.A13 | length 33.5
  L6 w0.101: C21F.2@45.832,30.783 46.142,30.783 46.374,30.551 46.374,21.326 60.05,7.65 60.05,6.05 59.65,5.65 P13H.A13@59.65,3.5
RX0_FORCEPLUG: Q14H.1 R31H.1 U10F.N22 | length 32.7
  L1 w0.1: v1(19.925,53.25) Q14H.1@19.925,54.175 ; v1(26.815,32.636) U10F.N22@27.515,32.636
  L4 w0.1: v1(19.925,53.25) 19.925,48.125 18.05,46.25 18.05,34.85 21.275,31.625 26.25,31.625 26.815,32.19 v1(26.815,32.636)
  L6 w0.1: v1(19.925,53.25) 19.925,53.725 R31H.1@20.4,54.2
RX0_FORCEUNPLUG: Q15H.1 R34H.1 U10F.M22 | length 37.1
  L1 w0.1: Q15H.1@15.925,54.175 15.95,54.15 v1(15.95,53.325) ; v1(27.522,31.929) U10F.M22@28.222,31.929
  L4 w0.1: v1(15.95,53.325) 16.825,52.45 16.825,50.525 17.625,49.725 17.625,34.65 20.95,31.325 26.918,31.325 v1(27.522,31.929)
  L6 w0.1: v1(15.95,53.325) 15.95,55.15 17.3,56.5 R34H.1@18.2,56.5
RX0_TMDS0_N: D15H.4 D15H.7 J11H.9 R13H.3 U10F.K21 | length 26.1
  L1 w0.1: J11H.9@10.16,23.5 11.51,23.5 11.86,23.15 12.175,23.15 12.45,23.425 13.075,23.425 13.15,23.5 D15H.4@13.538,23.5 D15H.7@14.413,23.5 14.8,23.5 14.9,23.4 17.075,23.4 19.625,25.95 19.625,28.149 21.376,29.9 28.13,29.9 28.346,30.116 28.414,30.116 29.049,30.751 29.487,31.19 29.809,31.19 29.99,31.01 30.131,31.01 U10F.K21@30.343,31.222
  L6 w0.1: R13H.3@26.96,30.09 27.26,30.09 27.435,29.915 27.59,29.915 27.76,30.085 v1(27.76,30.1)
RX0_TMDS0_P: D15H.5 D15H.6 J11H.7 R13H.4 U10F.K22 | length 26.1
  L1 w0.1: J11H.7@10.16,22.5 11.51,22.5 11.86,22.85 12.299,22.85 12.574,23.125 13.025,23.125 13.15,23 D15H.5@13.538,23 D15H.6@14.413,23 14.8,23 14.9,23.1 17.199,23.1 19.925,25.826 19.925,28.025 21.5,29.6 28.254,29.6 28.555,29.901 28.555,29.975 29.57,30.99 29.726,30.99 29.848,30.868 29.848,30.727 U10F.K22@29.636,30.515
  L6 w0.1: R13H.4@26.96,29.44 27.26,29.44 27.435,29.615 27.59,29.615 27.76,29.445 v1(27.76,29.39)
RX0_TMDS1_N: D16H.1 D16H.10 J11H.6 R12H.2 U10F.J20 | length 29
  L1 w0.1: J11H.6@10.16,22 11.51,22 11.86,21.65 13.075,21.65 13.15,21.725 D16H.1@13.538,21.725 D16H.10@14.413,21.725 14.8,21.725 14.9,21.625 22.825,21.625 26.675,25.475 26.675,27.049 29.417,29.792 29.479,29.792 30.509,30.822 30.907,31.22 31.193,31.22 31.347,31.067 31.532,31.067 31.687,31.222 U10F.J20@31.757,31.222 v1(32.457,31.222)
  L6 w0.1: v1(32.457,31.222) 32.457,31.58 32.547,31.67 32.82,31.67 33.27,31.22 R12H.2@33.27,31.16
RX0_TMDS1_P: D16H.2 D16H.9 J11H.4 R12H.1 U10F.J21 | length 29
  L1 w0.1: J11H.4@10.16,21 11.51,21 11.86,21.35 13.025,21.35 13.15,21.225 D16H.2@13.538,21.225 D16H.9@14.413,21.225 14.8,21.225 14.9,21.325 22.949,21.325 26.975,25.351 26.975,26.925 29.62,29.57 29.62,29.65 30.236,30.266 30.99,31.02 31.111,31.02 31.205,30.925 31.205,30.741 31.05,30.585 U10F.J21@31.05,30.515 v1(31.75,30.515)
  L6 w0.1: v1(31.75,30.515) 33.265,30.515 R12H.1@33.27,30.51
RX0_TMDS2_N: D16H.4 D16H.7 J11H.3 R11H.3 U10F.J22 | length 28.1
  L1 w0.1: J11H.3@10.16,20.5 11.51,20.5 11.86,20.15 13.075,20.15 13.15,20.225 D16H.4@13.538,20.225 D16H.7@14.413,20.225 14.8,20.225 14.9,20.125 23.825,20.125 28.025,24.325 28.025,26.709 30.43,29.114 30.43,29.721 U10F.J22@30.343,29.808 v1(31.043,29.808)
  L6 w0.1: R11H.3@30.547,29.077 30.76,29.289 31.007,29.289 31.059,29.341 31.059,29.791 v1(31.043,29.808)
RX0_TMDS2_P: D16H.5 D16H.6 J11H.1 R11H.4 U10F.H22 | length 28.2
  L1 w0.1: J11H.1@10.16,19.5 11.51,19.5 11.86,19.85 13.025,19.85 13.15,19.725 D16H.5@13.538,19.725 D16H.6@14.413,19.725 14.8,19.725 14.9,19.825 23.949,19.825 28.325,24.201 28.325,26.585 30.628,28.888 30.838,28.888 U10F.H22@31.05,29.101 v1(31.75,29.101)
  L6 w0.1: R11H.4@31.007,28.617 31.219,28.829 31.219,29.077 31.271,29.129 31.722,29.129 v1(31.75,29.101)
RX0_TMDS3_N: D15H.1 D15H.10 J11H.12 R14H.2 U10F.L19 | length 29.7
  L1 w0.1: J11H.12@10.16,25 11.51,25 11.86,24.65 12.175,24.65 12.425,24.9 13.05,24.9 13.15,25 D15H.1@13.538,25 D15H.10@14.413,25 14.8,25 14.9,24.9 16.4,24.9 17.75,26.25 17.75,29.024 20.226,31.5 24.984,31.5 25.384,31.1 27.21,31.1 27.25,31.06 27.477,31.06 27.807,31.39 28.247,31.39 28.386,31.529 28.388,31.529 28.622,31.763 28.622,31.765 29.093,32.236 29.095,32.236 29.329,32.47 29.329,32.472 29.8,32.943 29.802,32.943 30.036,33.177 30.036,33.179 30.167,33.31 30.518,33.31 30.697,33.131 30.838,33.131 U10F.L19@31.05,33.343 v1(31.75,33.343)
  L6 w0.1: v1(31.75,33.343) 32.013,33.343 32.36,33.69 32.36,34.08 32.59,34.31 32.76,34.31 32.91,34.16 R14H.2@32.91,33.89
RX0_TMDS3_P: D15H.2 D15H.9 J11H.10 R14H.1 U10F.L20 | length 29.7
  L1 w0.1: J11H.10@10.16,24 11.51,24 11.86,24.35 12.299,24.35 12.549,24.6 13.05,24.6 13.15,24.5 D15H.2@13.538,24.5 D15H.9@14.413,24.5 14.8,24.5 14.9,24.6 16.524,24.6 18.05,26.126 18.05,28.9 20.35,31.2 24.86,31.2 25.26,30.8 27.19,30.8 27.25,30.86 27.56,30.86 27.89,31.19 28.33,31.19 28.469,31.329 28.47,31.329 28.77,31.629 29.059,31.629 29.177,31.747 29.177,32.036 29.529,32.388 29.529,32.389 29.883,32.743 29.885,32.743 30.236,33.095 30.236,33.096 30.25,33.11 30.435,33.11 30.555,32.99 30.555,32.848 U10F.L20@30.343,32.636 v1(31.043,32.636)
  L6 w0.1: v1(31.043,32.636) 31.646,32.636 32.25,33.24 R14H.1@32.91,33.24
SMCLK: P13H.B5 U10F.D19 | length 34.6
  L1 w0.1: v1(35.3,28.393) U10F.D19@36,28.393 ; P13H.B5@49.65,3.5 v1(49.65,7.825)
  L6 w0.1: v1(35.3,28.393) 35.575,28.119 35.575,27.5 35.725,27.35 35.725,25.825 36.825,24.725 37.675,24.725 38.65,23.75 41.075,23.75 42.187,22.638 42.187,22.063 42.725,21.525 44,21.525 50.175,15.35 50.175,11.75 49.65,11.225 v1(49.65,7.825)
SMDAT: P13H.B6 U10F.D20 | length 33
  L1 w0.1: U10F.D20@35.293,27.686 v1(35.993,27.686) ; P13H.B6@50.65,3.5 v1(50.65,7.825)
  L6 w0.1: v1(35.993,27.686) 35.993,26.907 38.925,23.975 41.3,23.975 42.5,22.775 42.5,22.225 42.925,21.8 44.075,21.8 50.65,15.225 v1(50.65,7.825)
SRESET: C16C.1 P11C.17 R23C.2 R24C.2 SW10C.3 U11C.34 | length 51.7
  L1 w0.1: R24C.2@63.4,35.55 63.4,36.3 v1(63.925,36.825) ; U11C.34@66.5,40.475 v1(68.15,40.475) 69.6,40.475 69.8,40.275 74.825,40.275 82,47.45 R23C.2@82,48.75 ; R23C.2@82.1,48.65 SW10C.3@84.375,48.65 84.375,47.425 85.075,46.725 C16C.1@85.875,46.725
  L3 w0.1: P11C.17@56.31,25.23 57.55,26.47 57.55,28.075 58.825,29.35 63.8,29.35 65.1,30.65 65.1,35.15 63.925,36.325 63.925,37.375 64.55,38 66.25,38 66.925,38.675 66.925,39.25 v1(68.15,40.475)
STAT_LED: D10C.2 U11C.1 | length 11.7
  L1 w0.1: U11C.1@77.6,33.475 78.575,33.475 79.1,32.95 85.775,32.95 88.025,35.2 D10C.2@88.025,35.325
SW1.0: L10P.1 U10P.D3 U10P.D4 U10P.E3 U10P.E4 | length 7
  L1 w0.25: U10P.D4@57,35.475 57,36.25 ; U10P.D3@57.4,35.475 U10P.E3@57.4,35.875 57.4,36.25 ; 57.4,38 57.4,36.25 ; 57,36.25 57,37.775 57.2,37.575 57.2,36.275 57.375,36.275 57.4,36.25 ; 57,36.25 57.4,36.25
SW1.5: L12P.1 U12P.D3 U12P.D4 U12P.E3 U12P.E4 | length 7
  L1 w0.25: 66.65,66.95 68.4,66.95 ; U12P.D4@69.175,66.55 68.4,66.55 ; U12P.D3@69.175,66.95 U12P.E3@68.775,66.95 68.4,66.95 ; 68.4,66.55 68.4,66.95 ; 68.4,66.55 66.875,66.55 67.075,66.75 68.375,66.75 68.375,66.925 68.4,66.95
SW1.8: L11P.1 U11P.D3 U11P.D4 U11P.E3 U11P.E4 | length 7
  L1 w0.25: U11P.D3@42.45,19.675 U11P.E3@42.85,19.675 43.225,19.675 ; U11P.D4@42.45,20.075 43.225,20.075 ; 44.975,19.675 43.225,19.675 ; 43.225,19.675 43.25,19.7 43.25,19.875 44.55,19.875 44.75,20.075 43.225,20.075 ; 43.225,19.675 43.225,20.075
SW3.3: L13P.1 U13P.D3 U13P.D4 U13P.E3 U13P.E4 | length 7
  L1 w0.25: 82.15,67.375 83.9,67.375 ; U13P.D4@84.675,66.975 83.9,66.975 ; U13P.D3@84.675,67.375 U13P.E3@84.275,67.375 83.9,67.375 ; 83.9,66.975 83.9,67.375 ; 83.9,66.975 82.375,66.975 82.575,67.175 83.875,67.175 83.875,67.35 83.9,67.375
SW5.0: C28P.1 L14P.1 U16P.2 | length 31.1
  L1 w0.2: U16P.2@15.55,75.02 U16P.2@15.72,74.85 15.72,75.47 16,75.75 17.795,75.75 C28P.1@18.545,75 18.545,75.205 17.85,75.9 15.9,75.9 15.55,75.55 U16P.2@15.55,75.02
  L1 w0.7: v1@15.72,73.03 U16P.2@15.72,74.85
  L1 w1: L14P.1@18.1,63.35 17.3,64.15 15.975,64.15 15.85,64.275 15.85,65 17.225,65 18.475,63.75 L14P.1@18.475,62.55
  L3 w1.5: v1(15.875,75.775) 15.875,73.2 17.7,71.375 17.7,68.675 16.525,67.5 16.525,64.075 16.775,63.825
  other v1: 17.3,63.75 15.85,63.9 16.5,64.475 15.875,65.15 17.175,65.15 15.55,72.9 15.9,73.45 15.6,73.975
SYSCLK: U10F.J19 U11F.3 | length 4.1
  L1 w0.1: U10F.J19@32.464,31.929 32.464,32.639 32.95,33.125 33.375,33.125 v1(33.875,32.625)
  L6 w0.1: v1(33.875,32.625) 34.55,32.625 34.71,32.465 U11F.3@35.394,32.465
TCLK_SCK: P11C.15 R13C.1 U11C.22 | length 34.2
  L1 w0.1: R13C.1@71.85,45.3 73.3,43.85 U11C.22@73.3,42.775 v1(73.3,40.95)
  L4 w0.1: P11C.15@58.85,25.23 60.23,23.85 64.55,23.85 65.125,24.425 65.125,25.775 65.65,26.3 69.525,26.3 70.575,27.35 70.575,31.125 72.175,32.725 72.175,39.825 v1(73.3,40.95)
TMS_SWD: P11C.11 U11C.25 | length 23.1
  L1 w0.1: v1(71.8,41) U11C.25@71.8,42.775
  L4 w0.1: P11C.11@63.93,25.23 65.4,26.7 69.35,26.7 70.2,27.55 70.2,31.325 71.8,32.925 v1(71.8,41)
TX0_TMDS0_N: D11H.4 D11H.7 J10H.9 U10F.W22 | length 25.7
  L1 w0.1: J10H.9@10.16,47.5 11.51,47.5 11.86,47.15 12.05,47.15 12.45,47.55 13.025,47.55 13.1,47.625 D11H.4@13.487,47.625 D11H.7@14.362,47.625 14.75,47.625 14.85,47.525 16.849,47.525 18.325,46.049 18.325,36.9 19.8,35.425 22.301,35.425 22.646,35.77 22.72,35.77 23.8,36.85 23.8,36.916 23.683,37.033 23.497,37.033 23.343,36.879 U10F.W22@23.272,36.879
TX0_TMDS0_P: D11H.5 D11H.6 J10H.7 U10F.W21 | length 26.3
  L1 w0.1: J10H.7@10.16,46.5 11.51,46.5 11.86,46.85 12.174,46.85 12.574,47.25 12.975,47.25 13.1,47.125 D11H.5@13.487,47.125 D11H.6@14.362,47.125 14.75,47.125 14.85,47.225 16.725,47.225 18.025,45.925 18.025,36.776 19.676,35.125 22.425,35.125 22.861,35.561 22.861,35.629 24,36.767 24,36.999 23.825,37.175 23.825,37.361 23.979,37.515 U10F.W21@23.979,37.586
TX0_TMDS1_N: D12H.1 D12H.10 J10H.6 U10F.V20 | length 26.8
  L1 w0.1: J10H.6@10.16,46 11.51,46 11.86,45.65 13,45.65 13.1,45.75 D12H.1@13.487,45.75 D12H.10@14.362,45.75 14.75,45.75 14.85,45.65 16.024,45.65 17,44.674 17,36.175 18.875,34.3 22.606,34.3 23.289,34.983 23.357,34.983 25.393,37.02 U10F.V20@25.393,37.586
TX0_TMDS1_P: D12H.2 D12H.9 J10H.4 U10F.U20 | length 27.1
  L1 w0.1: J10H.4@10.16,45 11.51,45 11.86,45.35 13,45.35 13.1,45.25 D12H.2@13.487,45.25 D12H.9@14.362,45.25 14.75,45.25 14.85,45.35 15.9,45.35 16.7,44.55 16.7,36.051 18.751,34 22.73,34 23.498,34.768 23.498,34.842 25.535,36.879 U10F.U20@26.101,36.879
TX0_TMDS2_N: D12H.4 D12H.7 J10H.3 U10F.U21 | length 26.8
  L1 w0.1: J10H.3@10.16,44.5 11.51,44.5 11.86,44.15 13.025,44.15 13.1,44.225 13.1,44.25 D12H.4@13.488,44.25 13.875,44.25 D12H.7@14.362,44.25 14.75,44.25 14.85,44.15 15.299,44.15 15.7,43.749 15.7,35.525 18.225,33 21.55,33 21.7,33.15 22.075,33.15 22.225,33 22.716,33 23,33.284 23,33.525 23.23,33.755 23.47,33.755 23.952,34.236 24.024,34.236 25.393,35.606 U10F.U21@25.393,36.172
TX0_TMDS2_P: D12H.5 D12H.6 J10H.1 U10F.T21 | length 26.8
  L1 w0.1: J10H.1@10.16,43.5 11.51,43.5 11.86,43.85 13.025,43.85 13.1,43.775 13.1,43.75 D12H.5@13.487,43.75 D12H.6@14.362,43.75 14.75,43.75 14.85,43.85 15.175,43.85 15.4,43.625 15.4,35.401 18.101,32.7 22.84,32.7 24.165,34.025 24.165,34.095 25.535,35.464 U10F.T21@26.101,35.464
TX0_TMDS3_N: D11H.1 D11H.10 J10H.12 U10F.W19 | length 27.5
  L1 w0.1: J10H.12@10.16,49 11.51,49 11.86,48.65 12,48.65 12.375,49.025 13,49.025 13.1,49.125 D11H.1@13.487,49.125 D11H.10@14.362,49.125 14.75,49.125 14.85,49.025 17.699,49.025 19.675,47.049 19.675,37.725 21.01,36.39 21.866,36.39 22.133,36.658 22.202,36.658 24.515,38.97 24.858,38.97 25.04,38.788 25.181,38.788 U10F.W19@25.393,39
TX0_TMDS3_P: D11H.2 D11H.9 J10H.10 U10F.W20 | length 27.6
  L1 w0.1: J10H.10@10.16,48 11.51,48 11.86,48.35 12.124,48.35 12.499,48.725 13,48.725 13.1,48.625 D11H.2@13.487,48.625 D11H.9@14.362,48.625 14.75,48.625 14.85,48.725 17.575,48.725 19.375,46.925 19.375,37.601 20.125,36.851 20.125,36.7 20.3,36.525 20.451,36.525 20.886,36.09 21.99,36.09 22.344,36.444 22.344,36.516 24.598,38.77 24.775,38.77 24.898,38.646 24.898,38.505 U10F.W20@24.686,38.293
TX1_CEC: D21H.1 D21H.10 P10H.15 U10F.P17 | length 46.2
  L1 w0.1: v1(30.343,36.179) U10F.P17@30.343,36.879 ; P10H.15@34.6,72.525 34.6,71.85 34.925,71.525 36.35,71.525 37.325,70.55 D21H.10@37.325,69.888 D21H.1@37.325,69.013 37.35,68.988 v1(37.35,63.95)
  L4 w0.1: v1(30.343,36.179) 30.343,36.957 30.225,37.075 30.225,38.975 29.825,39.375 29.825,41.325 28.95,42.2 28.95,45.35 29.375,45.775 29.375,46.675 28.825,47.225 28.825,59.9 32.875,63.95 v1(37.35,63.95)
TX1_CLK_N: D22H.1 D22H.10 P10H.14 U10F.G21 | length 67.1
  L1 w0.1: v1(32.464,28.401) U10F.G21@32.464,29.101 ; P10H.14@34.4,73.75 34.4,74.3 34.35,74.35 34.35,74.65 34.75,75.05 v1@34.75,75.875 ; D22H.1@35.575,69.888 D22H.10@35.575,69.013 35.575,68.3 v1(35.675,68.2)
  L3 w0.1: v1(32.464,28.401) 32.456,28.392 31.932,28.392 31.674,28.65 27.624,28.65 27.1,29.174 27.1,29.52 19.84,36.78 19.84,43.766 35.475,59.401 35.475,68 v1(35.675,68.2) ; v1(34.95,75.875) 34.75,75.675 34.75,73.675 35.475,72.95 v1@35.475,68.2
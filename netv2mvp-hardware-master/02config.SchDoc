# Altium schematic sheet 02config.SchDoc
size B

## Parts
C10C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C11C  10uF, 6.3V, X5R  [CAPC1608N]
C12C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C13C  10uF, 10V, X5R (DNP)  [CAPC2012N]
C16C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C17C  10uF, 6.3V, X5R  [CAPC1608N]
C18C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C19C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C20C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C21C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C22C  10uF, 6.3V, X5R  [CAPC1608N]
C23C  0.1uF, 6.3V, X5R  [CAPC0603X03L]
D10C  red LED 0805  [CD2012-0805]
P10C  Male 4x1 2.54mm header (DNP)  [HDR1X4]
P11C  Female 10x2 2.54mm header (DNP)  [HDR2X10]
P12C  FCI 10103594-0001LF  [USB_MICRO_B_SMT]
R10C  2.4k, 1%  [CAPC0603X03L]
R11C  4.7k, 1%  [RESC1005N]
R12C  4.7k, 1%  [RESC1005N]
R13C  10k, 1%  [RESC1005N]
R14C  33, 1%  [RESC1005N]
R15C  33, 1%  [RESC1005N]
R16C  10k, 1%  [RESC1005N]
R17C  0 ohm  [RESC1005N]
R18C  DNP  [RESC1005N]
R19C  DNP  [RESC1005N]
R20C  100, 1%  [RESC1005N]
R21C  4.7k, 1%  [RESC1005N]
R22C  4.7k, 1%  [RESC1005N]
R23C  DNP  [RESC1005N]
R24C  DNP  [RESC1005N]
R25C  DNP  [RESC1005N]
R26C  DNP  [RESC1005N]
SW10C  5x5mm 1.6mm tall PB  [SWITCH_TS-1187A]
U10C  MX25L6436FM2I-08G  [SOIC127P790X216-8N]
U11C  K22F 64LQFP  [TSQFP50P1200X1200-64N]
Y10C  32.768kHz  [ABS07-120]

## Nets
GND: C10C.2 C11C.2 C12C.2 C13C.2 C16C.2 C17C.2 C18C.2 C19C.2 C20C.2 C21C.2 C22C.2 C23C.2 P10C.4 P11C.5 P11C.10 P11C.13 P11C.19 P12C.0(PAD) P12C.5(GND) R13C.2 R18C.2 SW10C.1 SW10C.2 U10C.4(VSS) U11C.4(VSS) U11C.15(VREFL) U11C.16(VSSA) U11C.31(VSS) U11C.47(VSS)
P3.3V: C10C.1 C17C.1 C18C.1 C19C.1 C20C.1 C21C.1 C22C.1 C23C.1 P10C.1 R10C.1 R11C.1 R12C.1 R16C.1 R17C.2 R20C.2 R21C.2 R22C.2 R23C.1 U10C.8(VCC) U11C.3(VDD) U11C.13(VDDA) U11C.14(VREFH) U11C.21(VBAT) U11C.30(VDD) U11C.48(VDD)
P5.0V: P11C.1 P11C.3
VUSB: P12C.1(VBUS) R19C.2
EZPCS_NMI: R16C.2 U11C.26(PTA4/LLWU_P3)
FPGA_DONE: U11C.36(PTB1)
FPGA_INIT: U11C.41(PTB18)
FPGA_MODE: U11C.35(PTB0/LLWU_P5)
FPGA_PROGRAM_B: R24C.1 U11C.42(PTB19)
FPGA_SPI_CS: R10C.2 U10C.1(~{CS})
FPGA_SPI_MISO_D1: U10C.2(DO)
FPGA_SPI_MOSI_D0: U10C.5(DI)
FPGA_SPI_RES_D3: R11C.2 U10C.7(~{HOLD})
FPGA_SPI_SCK: U10C.6(CLK)
FPGA_SPI_WP_D2: R12C.2 U10C.3(~{WP})
FPGA_TCK: P11C.8 U11C.62(PTD5)
FPGA_TDI: P11C.14 U11C.63(PTD6/LLWU_P15)
FPGA_TDO: P11C.16 U11C.64(PTD7)
FPGA_TMS: P11C.12 U11C.61(PTD4/LLWU_P14)
I2C0_SCL: R21C.1 U11C.37(PTB2)
I2C0_SDA: R22C.1 U11C.38(PTB3)
LPUART0_DEBUG_RX: P10C.2 R25C.2 U11C.46(PTC3/LLWU_P7)
LPUART0_DEBUG_TX: P10C.3 R26C.2 U11C.49(PTC4/LLWU_P8)
MCU_INT0: U11C.2(PTE1/LLWU_P0)
MCU_INT1: U11C.43(PTC0)
SRESET: C16C.1 P11C.17 R23C.2 R24C.2 SW10C.3 U11C.34(~{RESET})
STAT_LED: D10C.2(K) U11C.1(PTE0/CLKOUT32K)
TCLK_SCK: P11C.15 R13C.1 U11C.22(PTA0)
TMS_SWD: P11C.11 U11C.25(PTA3)
UART0_RX: P11C.7 R25C.1 U11C.39(PTB16)
UART0_TX: P11C.9 R26C.1 U11C.40(PTB17)
USB0_N: R15C.2 U11C.6(USB0_DM)
USB0_P: R14C.2 U11C.5(USB0_DP)
USBD_N: P12C.2(D-) R15C.1
USBD_P: P12C.3(D+) R14C.1
USBVDD: C11C.1 C12C.1 R17C.1 U11C.7(USBVDD(100)/VOUT33(120))
VREG_OPT: C13C.1 R19C.1 U11C.8(NC(100)/VREGIN(120))
NetD10C_1: D10C.1(A) R20C.1
NetP12C_4: P12C.4(ID) R18C.1
NetU11C_19: U11C.19(XTAL32) Y10C.2(OSC2)
NetU11C_20: U11C.20(EXTAL32) Y10C.1(OSC1)

Not connected (* = marked no-connect by the designer): P11C 2 4 6 18 20; SW10C 4; U11C 9(ADC_DP0/ADC1_DP3) 10(ADC0_DM0/ADC1_DM3) 11(ADC1_DP0/ADC0_DP3) 12(ADC1_DM0/ADC0_DM3) 17(VREF_OUT/CMP1_IN5/CMP0_IN5/ADC1_SE18) 18(DAC0_OUT/CMP1_IN3/ADC0_SE23) 23(PTA1) 24(PTA2) 27(PTA5) 28(PTA12) 29(PTA13/LLWU_P4) 32(PTA18) 33(PTA19) 44(PTC1/LLWU_P6) 45(PTC2) 50(PTC5/LLWU_P9) 51(PTC6/LLWU_P10) 52(PTC7) 53(PTC8) 54(PTC9) 55(PTC10) 56(PTC11/LLWU_P11) 57(PTD0/LLWU_P12) 58(PTD1) 59(PTD2/LLWU_P13) 60(PTD3)

## Layout directives
differential pair: USB0_N, USB0_P, USBD_N, USBD_P
net class USB_NETS: USB0_N, USB0_P, USBD_N, USBD_P

## Notes on the sheet
- top view from Rpi
- (near U10C) x2 part for easy availability, works with RPi config (
  40ms config @ x2, 66MHz)
- needs x4 part for <100ms PCIe config time (67 ms)
- Rpi Vertical Stack Header
- (near P11C) Note: mirrored pinout because
- (near P11C) connector faces *down* on FPGA board
- Use "34" option for long tails
- Use "44" option for more connector clearance
- With "44" option, standoff height is 0.735" / 18.67mm
- With "34" option, standoff height is 0.635" / 16.13mm
- (near R24C) 0 ohm when U11C not present
- FPGA
- Licensed under CERN OHL v1.2 or later
- Copyright 2017 Andrew "bunnie" Huang

## Library data of the parts
C10C C12C C16C C18C C19C C20C C21C C23C = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A104KQ3NNNC; VENDOR: Samsung; MYPN: C-104-6p3-X5R-0201
C11C C17C C22C = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL10A106MQ8NNNC; VENDOR: Samsung; MYPN: C-106-6.3-X5R-0603
C13C = Cap Semi: Capacitor (Semiconductor SIM Model); VENDOR: Samsung
D10C = LED2: Red LED; MPN: CB-2012QRC-P8; MYPN: D-LED-RED-0805; VENDOR: Cheng Guang Xing
P10C = Header 4: Header, 4-Pin; MYPN: J-HDR-2.54-4x1-STD-DNP
P11C = Header 10X2: Header, 10-Pin, Dual row; MPN: (ESQ/ESW)-110-(34/44/69)-(L/G)-D; VENDOR: Samtech; MYPN: ESW-110-44-L-D
P12C = USB_MINI-AB_1: Micro USB B type connector; VENDOR: FCI/BERG; MYPN: J-MICROUSB-SMT-FCI
R10C = Res1: Resistor; VENDOR: ANY; MYPN: R-242-1P-1_16W-0201
R11C R12C = Res1: Resistor; MPN: RS02U472FT; VENDOR: Fenghua; MYPN: R-472-1P-1_16W-0402
R13C R16C = Res1: Resistor; MPN: RS02U103FT; VENDOR: Fenghua; MYPN: R-103-1P-1_16W-0402
R14C R15C = Res1: Resistor; MPN: RS02U330FT; VENDOR: Fenghua; MYPN: R-330-1P-1_16W-0402
R17C = Res1: Resistor; VENDOR: ANY; MYPN: R-0R0-1P-1_16W-0402
R18C R19C R24C R25C R26C = Res1: Resistor; VENDOR: ANY
R20C = Res1: Resistor; MPN: RS02U101FT; VENDOR: Fenghua; MYPN: R-101-1P-1_16W-0402
R21C R22C = Res1: Resistor; VENDOR: ANY; MYPN: R-472-1P-1_16W-0402
R23C = Res1: Resistor; VENDOR: Fenghua
SW10C = Header 4: Chi Fung TS-1187A; MPN: SW-PB-5X5-1.6; VENDOR: Kangdeli
U10C = EN25P05-50GCP: 64Mbit SPI NOR FLASH; MYPN: UMX25L6436FM2I-08G; VENDOR: Macronix
U11C = MK22-64LQFP: NXP K22F series 64LQFP device; MPN: MK22FN128VLH10; MFG: NXP/FREESCALE; MYPN: U-MK22FN128VLH10
Y10C = XTAL: 3.2 x 1.5mm 32.768 kHz crystal, 6pF CL 70k ESR, 20ppm; MPN: SJFC1332K06F20; VENDOR: Songji; MYPN: X-32.768K-SONGJI
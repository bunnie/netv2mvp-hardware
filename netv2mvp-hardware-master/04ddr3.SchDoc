# Altium schematic sheet 04ddr3.SchDoc
size B

## Parts
C10D  4.7uF, 6.3V, X5R  [CAPC1005N]
C11D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C12D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C13D  100uF, 6.3V, X5R  [CAPC3216N]
C14D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C15D  4.7uF, 6.3V, X5R  [CAPC1005N]
C16D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C17D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C18D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C19D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C20D  4.7uF, 6.3V, X5R  [CAPC1005N]
C21D  4.7uF, 6.3V, X5R  [CAPC1005N]
C22D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C23D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C24D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C25D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C26D  4.7uF, 6.3V, X5R  [CAPC1005N]
C27D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C28D  4.7uF, 6.3V, X5R  [CAPC1005N]
C29D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C30D  4.7uF, 6.3V, X5R  [CAPC1005N]
C31D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C32D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C33D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C34D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C35D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C36D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C37D  4.7uF, 6.3V, X5R  [CAPC1005N]
C38D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C39D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C40D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C41D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C42D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C43D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C44D  4.7uF, 6.3V, X5R  [CAPC1005N]
C45D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C46D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C47D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C48D  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C49D  100uF, 6.3V, X5R  [CAPC3216N]
C50D  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C51D  3.3pF, NP0  [CAPC0603X03L]
R10D  240, 1%  [CAPC0603X03L]
R11D  4.7k, 1%  [RESC1005N]
R12D  39, 1%  [RESC1005N]
R13D  39, 1%  [RESC1005N]
R14D  240, 1%  [CAPC0603X03L]
RP10D  39, 5%  [PANASONIC_EXB28V]
RP11D  39, 5%  [PANASONIC_EXB28V]
RP12D  39, 5%  [PANASONIC_EXB28V]
RP13D  39, 5%  [PANASONIC_EXB28V]
RP14D  39, 5%  [PANASONIC_EXB28V]
RP15D  39, 5%  [PANASONIC_EXB28V]
U10D  MT41J128M16HA-125  [MICT-HA-96]  (parts A,B,C of 3)
U11D  MT41J128M16HA-125  [MICT-HA-96]  (parts A,B,C of 3)

## Nets
GND: C10D.1 C11D.2 C12D.2 C13D.2 C14D.2 C15D.2 C16D.2 C17D.2 C18D.2 C19D.2 C20D.2 C21D.2 C22D.2 C23D.2 C24D.2 C25D.2 C26D.2 C27D.1 C28D.2 C29D.1 C30D.1 C31D.2 C32D.2 C33D.1 C34D.1 C35D.1 C36D.2 C37D.2 C38D.2 C39D.2 C40D.2 C41D.2 C42D.1 C43D.1 C44D.2 C45D.2 C46D.2 C47D.2 C48D.2 C49D.1 R10D.1 R11D.1 R14D.1 U10D.A9(VSS) U10D.B1(VSSQ) U10D.B3(VSS) U10D.B9(VSSQ) U10D.D1(VSSQ) U10D.D8(VSSQ) U10D.E1(VSS) U10D.E2(VSSQ) U10D.E8(VSSQ) U10D.F9(VSSQ) U10D.G1(VSSQ) U10D.G8(VSS) U10D.G9(VSSQ) U10D.J2(VSS) U10D.J8(VSS) U10D.M1(VSS) U10D.M9(VSS) U10D.P1(VSS) U10D.P9(VSS) U10D.T1(VSS) U10D.T9(VSS) U11D.A9(VSS) U11D.B1(VSSQ) U11D.B3(VSS) U11D.B9(VSSQ) U11D.D1(VSSQ) U11D.D8(VSSQ) U11D.E1(VSS) U11D.E2(VSSQ) U11D.E8(VSSQ) U11D.F9(VSSQ) U11D.G1(VSSQ) U11D.G8(VSS) U11D.G9(VSSQ) U11D.J2(VSS) U11D.J8(VSS) U11D.M1(VSS) U11D.M9(VSS) U11D.P1(VSS) U11D.P9(VSS) U11D.T1(VSS) U11D.T9(VSS)
P1.5V_D: C14D.1 C15D.1 C16D.1 C17D.1 C18D.1 C19D.1 C21D.1 C22D.1 C23D.1 C24D.1 C25D.1 C36D.1 C37D.1 C38D.1 C39D.1 C40D.1 C41D.1 C44D.1 C45D.1 C46D.1 C47D.1 C48D.1 C49D.2 C50D.1 U10D.A1(VDDQ) U10D.A8(VDDQ) U10D.B2(VDD) U10D.C1(VDDQ) U10D.C9(VDDQ) U10D.D2(VDDQ) U10D.D9(VDD) U10D.E9(VDDQ) U10D.F1(VDDQ) U10D.G7(VDD) U10D.H2(VDDQ) U10D.H9(VDDQ) U10D.K2(VDD) U10D.K8(VDD) U10D.N1(VDD) U10D.N9(VDD) U10D.R1(VDD) U10D.R9(VDD) U11D.A1(VDDQ) U11D.A8(VDDQ) U11D.B2(VDD) U11D.C1(VDDQ) U11D.C9(VDDQ) U11D.D2(VDDQ) U11D.D9(VDD) U11D.E9(VDDQ) U11D.F1(VDDQ) U11D.G7(VDD) U11D.H2(VDDQ) U11D.H9(VDDQ) U11D.K2(VDD) U11D.K8(VDD) U11D.N1(VDD) U11D.N9(VDD) U11D.R1(VDD) U11D.R9(VDD)
VTT: C13D.1 C20D.1 C26D.1 C27D.2 C28D.1 C29D.2 C33D.2 C34D.2 C35D.2 C42D.2 C43D.2 RP10D.1(R1) RP10D.2(R2) RP10D.3(R3) RP10D.4(R4) RP11D.1(R1) RP11D.2(R2) RP11D.3(R3) RP11D.4(R4) RP12D.1(R1) RP12D.2(R2) RP12D.3(R3) RP12D.4(R4) RP13D.1(R1) RP13D.2(R2) RP13D.3(R3) RP13D.4(R4) RP14D.1(R1) RP14D.2(R2) RP14D.3(R3) RP14D.4(R4) RP15D.1(R1) RP15D.2(R2) RP15D.3(R3) RP15D.4(R4)
VTT_REF: C10D.2 C11D.1 C12D.1 C30D.2 C31D.1 C32D.1 U10D.H1(VREFDQ) U10D.M8(VREFCA) U11D.H1(VREFDQ) U11D.M8(VREFCA)
DDR3_A0: RP12D.5(R42) U10D.N3(A0) U11D.N3(A0)
DDR3_A1: RP12D.7(R22) U10D.P7(A1) U11D.P7(A1)
DDR3_A2: RP12D.8(R12) U10D.P3(A2) U11D.P3(A2)
DDR3_A3: RP13D.7(R22) U10D.N2(A3) U11D.N2(A3)
DDR3_A4: RP14D.5(R42) U10D.P8(A4) U11D.P8(A4)
DDR3_A5: RP15D.7(R22) U10D.P2(A5) U11D.P2(A5)
DDR3_A6: RP14D.7(R22) U10D.R8(A6) U11D.R8(A6)
DDR3_A7: RP15D.6(R32) U10D.R2(A7) U11D.R2(A7)
DDR3_A8: RP15D.5(R42) U10D.T8(A8) U11D.T8(A8)
DDR3_A9: RP15D.8(R12) U10D.R3(A9) U11D.R3(A9)
DDR3_A10: RP10D.8(R12) U10D.L7(A10/AP) U11D.L7(A10/AP)
DDR3_A11: RP13D.5(R42) U10D.R7(A11) U11D.R7(A11)
DDR3_A12: RP13D.6(R32) U10D.N7(A12/BC#) U11D.N7(A12/BC#)
DDR3_A13: RP14D.6(R32) U10D.T3(A13) U11D.T3(A13)
DDR3_BA0: RP13D.8(R12) U10D.M2(BA0) U11D.M2(BA0)
DDR3_BA1: RP12D.6(R32) U10D.N8(BA1) U11D.N8(BA1)
DDR3_BA2: RP11D.6(R32) U10D.M3(BA2) U11D.M3(BA2)
DDR3_CAS_N: RP10D.6(R32) U10D.K3(CAS#) U11D.K3(CAS#)
DDR3_CK_N: C51D.1 R13D.1 U10D.K7(CK#) U11D.K7(CK#)
DDR3_CK_P: C51D.2 R12D.1 U10D.J7(CK) U11D.J7(CK)
DDR3_CKE: RP10D.7(R22) U10D.K9(CKE) U11D.K9(CKE)
DDR3_CS0_N: RP10D.5(R42) U10D.L2(CS#) U11D.L2(CS#)
DDR3_DM0: U11D.E7(LDM)
DDR3_DM1: U11D.D3(UDM)
DDR3_DM2: U10D.E7(LDM)
DDR3_DM3: U10D.D3(UDM)
DDR3_DQ0: U11D.E3(DQ0)
DDR3_DQ1: U11D.F7(DQ1)
DDR3_DQ2: U11D.F2(DQ2)
DDR3_DQ3: U11D.F8(DQ3)
DDR3_DQ4: U11D.H3(DQ4)
DDR3_DQ5: U11D.H8(DQ5)
DDR3_DQ6: U11D.G2(DQ6)
DDR3_DQ7: U11D.H7(DQ7)
DDR3_DQ8: U11D.D7(DQ8)
DDR3_DQ9: U11D.C3(DQ9)
DDR3_DQ10: U11D.C8(DQ10)
DDR3_DQ11: U11D.C2(DQ11)
DDR3_DQ12: U11D.A7(DQ12)
DDR3_DQ13: U11D.A2(DQ13)
DDR3_DQ14: U11D.B8(DQ14)
DDR3_DQ15: U11D.A3(DQ15)
DDR3_DQ16: U10D.E3(DQ0)
DDR3_DQ17: U10D.F7(DQ1)
DDR3_DQ18: U10D.F2(DQ2)
DDR3_DQ19: U10D.F8(DQ3)
DDR3_DQ20: U10D.H3(DQ4)
DDR3_DQ21: U10D.H8(DQ5)
DDR3_DQ22: U10D.G2(DQ6)
DDR3_DQ23: U10D.H7(DQ7)
DDR3_DQ24: U10D.D7(DQ8)
DDR3_DQ25: U10D.C3(DQ9)
DDR3_DQ26: U10D.C8(DQ10)
DDR3_DQ27: U10D.C2(DQ11)
DDR3_DQ28: U10D.A7(DQ12)
DDR3_DQ29: U10D.A2(DQ13)
DDR3_DQ30: U10D.B8(DQ14)
DDR3_DQ31: U10D.A3(DQ15)
DDR3_DQS0_N: U11D.G3(LDQS#)
DDR3_DQS0_P: U11D.F3(LDQS)
DDR3_DQS1_N: U11D.B7(UDQS#)
DDR3_DQS1_P: U11D.C7(UDQS)
DDR3_DQS2_N: U10D.G3(LDQS#)
DDR3_DQS2_P: U10D.F3(LDQS)
DDR3_DQS3_N: U10D.B7(UDQS#)
DDR3_DQS3_P: U10D.C7(UDQS)
DDR3_ODT0: RP11D.7(R22) U10D.K1(ODT) U11D.K1(ODT)
DDR3_RAS_N: RP11D.8(R12) U10D.J3(RAS#) U11D.J3(RAS#)
DDR3_RESET_N: R11D.2 U10D.T2(RESET#) U11D.T2(RESET#)
DDR3_WE_N: RP11D.5(R42) U10D.L3(WE#) U11D.L3(WE#)
NetC50D_2: C50D.2 R12D.2 R13D.2
NetR10D_2: R10D.2 U10D.L8(ZQ)
NetR14D_2: R14D.2 U11D.L8(ZQ)

Not connected (* = marked no-connect by the designer): RP14D 8(R12); U10D J1(NC)* J9(NC)* L1(NC)* L9(NC)* M7(NC)* T7(NC)*; U11D J1(NC)* J9(NC)* L1(NC)* L9(NC)* M7(NC)* T7(NC)*

## Layout directives
net class SE40: DDR3_A0, DDR3_A1, DDR3_A2, DDR3_A3, DDR3_A4, DDR3_A5, DDR3_A6, DDR3_A7, DDR3_A8, DDR3_A9, DDR3_A10, DDR3_A11, DDR3_A12, DDR3_A13, DDR3_BA0, DDR3_BA1, DDR3_BA2, DDR3_CAS_N, DDR3_CKE, DDR3_CS0_N, DDR3_ODT0, DDR3_RAS_N, DDR3_WE_N
net class DP80: DDR3_CK_N, DDR3_CK_P
net class B0_SE40: DDR3_DM0, DDR3_DQ0, DDR3_DQ1, DDR3_DQ2, DDR3_DQ3, DDR3_DQ4, DDR3_DQ5, DDR3_DQ6, DDR3_DQ7
net class B2_SE40: DDR3_DM2, DDR3_DQ16, DDR3_DQ17, DDR3_DQ18, DDR3_DQ19, DDR3_DQ20, DDR3_DQ21, DDR3_DQ22, DDR3_DQ23
net class B1_SE40: DDR3_DM1, DDR3_DQ8, DDR3_DQ9, DDR3_DQ10, DDR3_DQ11, DDR3_DQ12, DDR3_DQ13, DDR3_DQ14, DDR3_DQ15
net class B3_SE40: DDR3_DM3, DDR3_DQ24, DDR3_DQ25, DDR3_DQ26, DDR3_DQ27, DDR3_DQ28, DDR3_DQ29, DDR3_DQ30, DDR3_DQ31
net class B3_DP80: DDR3_DQS3_N, DDR3_DQS3_P
net class B2_DP80: DDR3_DQS2_N, DDR3_DQS2_P
net class B1_DP80: DDR3_DQS1_N, DDR3_DQS1_P
net class B0_DP80: DDR3_DQS0_N, DDR3_DQS0_P

## Notes on the sheet
- (near R11D) PUDC problem?
- Licensed under CERN OHL v1.2 or later
- Copyright 2016 Andrew "bunnie" Huang

## Library data of the parts
C10D C15D C20D C21D C26D C28D C30D C37D C44D = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL05A475MQ5NQNC; VENDOR: Samsung; MYPN: C-475-6p3-X5R-0402
C11D C12D C14D C16D C17D C18D C19D C27D C29D C31D C32D C33D C34D C35D C36D C38D C39D C40D C41D C42D C43D C50D = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A104KQ3NNNC; VENDOR: Samsung; MYPN: C-104-6p3-X5R-0201
C13D C49D = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL31A107MQHNNNE; VENDOR: Samsung; MYPN: C-107-6p3-X5R-1206
C22D C23D C24D C25D C45D C46D C47D C48D = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A224MQ3NNNC; VENDOR: Samsung; MYPN: C-224-6p3-X5R-0201
C51D = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: GRM0335C1H3R3CA01D; VENDOR: Murata; MYPN: C-3R3-50-NP0-0201
R10D R14D = Res1: Resistor; VENDOR: ANY; MYPN: R-241-1P-1_16W-0201
R11D = Res1: Resistor; VENDOR: ANY; MYPN: R-472-1P-1_16W-0402
R12D R13D = Res1: Resistor; VENDOR: ANY; MYPN: R-390-1P-1_16W-0402
RP10D RP11D RP12D RP13D RP14D RP15D = RPACK4: MPN: RP104PJ390CS; MYPN: R-390-RP4-0402-5P-CVEX; VENDOR: Samsung
U10D = MT41J128M16HA-125: 2Gb DDR3-1600 SDRAM, 128Mb x 16, 1.25ns, 1.5V, 0 to 95 degC, 96-Ball FBGA, Pb-Free; MPN: MT41J128M16JT-125:K; CL: CL = 11; Clock Rate: 800 MHz; Op. Temp.: 0C to +95C; VENDOR: Micron; MYPN: UDDR3-128M16-125-96BGA
U11D = MT41J128M16HA-125: 2Gb DDR3-1600 SDRAM, 128Mb x 16, 1.25ns, 1.5V, 0 to 95 degC, 96-Ball FBGA, Pb-Free; MPN: MT41J128M16JT-125:K; CL: CL = 11; Clock Rate: 800 MHz; Op. Temp.: 0C to +95C; Vendor: Micron; MYPN: UDDR3-128M16-125-96BGA
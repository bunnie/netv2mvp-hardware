# Altium schematic sheet 03fpga.SchDoc
size C

## Parts
C10F  4.7uF, 6.3V, X5R  [CAPC1005N]
C11F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C12F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C13F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C14F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C15F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C16F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C17F  4.7uF, 6.3V, X5R  [CAPC1005N]
C18F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C19F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C20F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C21F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C22F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C23F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C24F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C25F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C26F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C27F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C28F  4.7uF, 6.3V, X5R  [CAPC1005N]
C29F  4.7uF, 6.3V, X5R  [CAPC1005N]
C30F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C31F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C32F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C33F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C34F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C35F  100uF, 6.3V, X5R  [CAPC3216N]
C36F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C37F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C38F  4.7uF, 6.3V, X5R  [CAPC1005N]
C39F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C40F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C41F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C42F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C43F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C44F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C45F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C46F  4.7uF, 6.3V, X5R  [CAPC1005N]
C47F  4.7uF, 6.3V, X5R  [CAPC1005N]
C48F  4.7uF, 6.3V, X5R  [CAPC1005N]
C49F  100uF, 6.3V, X5R  [CAPC3216N]
C50F  100uF, 6.3V, X5R  [CAPC3216N]
C51F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C52F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C53F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C54F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C55F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C56F  4.7uF, 6.3V, X5R  [CAPC1005N]
C57F  4.7uF, 6.3V, X5R  [CAPC1005N]
C58F  4.7uF, 6.3V, X5R  [CAPC1005N]
C59F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C60F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C61F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C62F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C63F  4.7uF, 6.3V, X5R  [CAPC1005N]
C64F  4.7uF, 6.3V, X5R  [CAPC1005N]
C65F  4.7uF, 6.3V, X5R  [CAPC1005N]
C66F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C67F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C68F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C69F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C70F  4.7uF, 6.3V, X5R  [CAPC1005N]
C71F  4.7uF, 6.3V, X5R  [CAPC1005N]
C72F  4.7uF, 6.3V, X5R  [CAPC1005N]
C73F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C74F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C75F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C76F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C77F  4.7uF, 6.3V, X5R  [CAPC1005N]
C78F  4.7uF, 6.3V, X5R  [CAPC1005N]
C79F  4.7uF, 6.3V, X5R  [CAPC1005N]
C80F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C81F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C82F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C83F  0.47uF, 6.3V, X5R  [CAPC0603X03L]
C84F  4.7uF, 6.3V, X5R  [CAPC1005N]
C85F  4.7uF, 6.3V, X5R  [CAPC1005N]
C86F  4.7uF, 6.3V, X5R  [CAPC1005N]
C87F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C88F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C89F  0.1uF, 6.3V, X5R  [CAPC0603X03L]
D10F  white LED  [CD2012-0805]
D11F  white LED  [CD2012-0805]
D12F  white LED  [CD2012-0805]
P10F  Header 2 (DNP)  [HDR1X2]
R10F  1k, 1%  [RESC1005N]
R11F  100, 1%  [RESC1005N]
R12F  4.7k, 1%  [RESC1005N]
R13F  4.7k, 1%  [RESC1005N]
R14F  330, 1%  [RESC1005N]
R15F  1.0k, 1%  [RESC1005N]
R16F  100, 1%  [RESC1005N]
R17F  100, 1%  [RESC1005N]
R18F  100, 1%  [RESC1005N]
U10F  XC7A35T-2FGG484C  [FGG484]  (parts A,B,C,D,E,F,G,H,I,J,K,L of 12)
U11F  50 MHz oscillator  [ABRACON_ASDMB]

## Nets
GND: C10F.2 C11F.2 C12F.2 C13F.2 C14F.2 C15F.2 C16F.2 C17F.2 C18F.2 C19F.2 C26F.2 C28F.2 C29F.2 C30F.2 C31F.2 C32F.2 C33F.2 C34F.2 C35F.2 C38F.2 C39F.2 C41F.2 C42F.2 C43F.2 C44F.2 C45F.2 C46F.2 C47F.2 C48F.2 C49F.2 C50F.2 C51F.2 C52F.2 C53F.2 C54F.2 C55F.2 C56F.2 C57F.2 C58F.2 C59F.2 C60F.2 C61F.2 C62F.2 C63F.2 C64F.2 C65F.2 C66F.2 C67F.2 C68F.2 C69F.2 C70F.2 C71F.2 C72F.2 C73F.2 C74F.2 C75F.2 C76F.2 C77F.2 C78F.2 C79F.2 C80F.2 C81F.2 C82F.2 C83F.2 C84F.2 C85F.2 C86F.2 C87F.2 C88F.2 C89F.2 D10F.2(K) D11F.2(K) D12F.2(K) R10F.2 R15F.1 U10F.A2(GND) U10F.A3(GND) U10F.A5(GND) U10F.A7(GND) U10F.A9(GND) U10F.A11(GND) U10F.A12(GND) U10F.A22(GND) U10F.AA2(GND) U10F.AA12(GND) U10F.AA22(GND) U10F.AB9(GND) U10F.AB19(GND) U10F.B3(GND) U10F.B12(GND) U10F.B19(GND) U10F.C3(GND) U10F.C6(GND) U10F.C10(GND) U10F.C12(GND) U10F.C16(GND) U10F.D3(GND) U10F.D4(GND) U10F.D8(GND) U10F.D12(GND) U10F.D13(GND) U10F.E4(GND) U10F.E5(GND) U10F.E7(GND) U10F.E9(GND) U10F.E11(GND) U10F.E20(GND) U10F.F5(GND) U10F.F11(GND) U10F.F17(GND) U10F.G5(GND) U10F.G6(GND) U10F.G7(GND) U10F.G8(GND) U10F.G9(GND) U10F.G10(GND) U10F.G12(GND) U10F.G14(GND) U10F.H1(GND) U10F.H7(GND) U10F.H9(GND) U10F.H11(GND) U10F.H21(GND) U10F.J8(GND) U10F.J10(GND) U10F.J12(GND) U10F.J18(GND) U10F.K5(GND) U10F.K7(GND) U10F.K9(GNDADC_0) U10F.K11(GND) U10F.K15(GND) U10F.L2(GND) U10F.L8(GND) U10F.L9(VREFN_0) U10F.L10(VP_0) U10F.L22(GND) U10F.M7(GND) U10F.M9(VN_0) U10F.M10(VREFP_0) U10F.M11(GND) U10F.M19(GND) U10F.N6(GND) U10F.N8(GND) U10F.N9(DXN_0) U10F.N10(DXP_0) U10F.N16(GND) U10F.P3(GND) U10F.P7(GND) U10F.P9(GND) U10F.P11(GND) U10F.P13(GND) U10F.R8(GND) U10F.R10(GND) U10F.R12(GND) U10F.R20(GND) U10F.T7(GND) U10F.T9(GND) U10F.T11(GND) U10F.T17(GND) U10F.U4(GND) U10F.U10(M1_0) U10F.U14(GND) U10F.V1(GND) U10F.V11(GND) U10F.V21(GND) U10F.W8(GND) U10F.W18(GND) U10F.Y5(GND) U10F.Y15(GND) U11F.2(GND)
P1.0V: C10F.1 C11F.1 C12F.1 C38F.1 C39F.1 C41F.1 C42F.1 C43F.1 C44F.1 C45F.1 C46F.1 C47F.1 C48F.1 C49F.1 U10F.D6(MGTAVCC) U10F.D10(MGTAVCC) U10F.E8(MGTAVCC) U10F.F7(MGTAVCC) U10F.F9(MGTAVCC) U10F.H8(VCCINT) U10F.H10(VCCINT) U10F.J7(VCCINT) U10F.J9(VCCINT) U10F.J11(VCCBRAM) U10F.K8(VCCINT) U10F.L7(VCCINT) U10F.L11(VCCBRAM) U10F.M8(VCCINT) U10F.N7(VCCINT) U10F.N11(VCCBRAM) U10F.P8(VCCINT) U10F.P10(VCCINT) U10F.R7(VCCINT) U10F.R9(VCCINT) U10F.T8(VCCINT) U10F.T10(VCCINT)
P1.2VTT: C15F.1 C16F.1 C17F.1 C87F.1 C88F.1 R11F.2 U10F.B5(MGTAVTT) U10F.B7(MGTAVTT) U10F.B9(MGTAVTT) U10F.B11(MGTAVTT) U10F.C4(MGTAVTT) U10F.C8(MGTAVTT)
P1.5V_D: C59F.1 C60F.1 C61F.1 C62F.1 C63F.1 C64F.1 C65F.1 C73F.1 C74F.1 C75F.1 C76F.1 C77F.1 C78F.1 C79F.1 U10F.AA7(VCCO_34) U10F.AB4(VCCO_34) U10F.C1(VCCO_35) U10F.F2(VCCO_35) U10F.H6(VCCO_35) U10F.J3(VCCO_35) U10F.M4(VCCO_35) U10F.N1(VCCO_35) U10F.R5(VCCO_34) U10F.T2(VCCO_34) U10F.V6(VCCO_34) U10F.W3(VCCO_34)
P1.8V: C26F.1 C28F.1 C29F.1 C30F.1 C31F.1 C32F.1 C33F.1 C34F.1 C35F.1 U10F.E12(VCCBATT_0) U10F.H12(VCCAUX) U10F.K10(VCCADC_0) U10F.K12(VCCAUX) U10F.M12(VCCAUX) U10F.P12(VCCAUX) U10F.R11(VCCAUX)
P3.3V: C50F.1 C51F.1 C52F.1 C53F.1 C54F.1 C55F.1 C56F.1 C57F.1 C58F.1 C66F.1 C67F.1 C68F.1 C69F.1 C70F.1 C71F.1 C72F.1 C80F.1 C81F.1 C82F.1 C83F.1 C84F.1 C85F.1 C86F.1 C89F.1 P10F.2 R12F.2 R13F.2 R14F.2 U10F.A17(VCCO_16) U10F.AA17(VCCO_13) U10F.AB14(VCCO_13) U10F.B14(VCCO_16) U10F.C21(VCCO_16) U10F.D18(VCCO_16) U10F.E15(VCCO_16) U10F.F12(VCCO_0) U10F.F22(VCCO_16) U10F.G19(VCCO_15) U10F.H16(VCCO_15) U10F.J13(VCCO_15) U10F.K20(VCCO_15) U10F.L17(VCCO_15) U10F.M14(VCCO_14) U10F.N21(VCCO_15) U10F.P18(VCCO_14) U10F.R15(VCCO_14) U10F.T12(VCCO_0) U10F.T22(VCCO_14) U10F.U8(CFGBVS_0) U10F.U11(M0_0) U10F.U19(VCCO_14) U10F.V16(VCCO_13) U10F.W13(VCCO_13) U10F.Y10(VCCO_13) U10F.Y20(VCCO_14) U11F.1(OE) U11F.4(Vcc)
VTT_REF: C13F.1 C14F.1 C18F.1 C19F.1 U10F.E3(IO_L6N_T0_VREF_35) U10F.N3(IO_L19N_T3_VREF_35) U10F.V3(IO_L6N_T0_VREF_34) U10F.W7(IO_L19N_T3_VREF_34)
CEC_R: U10F.P20(IO_0_14)
DDC_SCL_LV_N: U10F.T18(IO_L20N_T3_A07_D23_14)
DDC_SDA_LV_N: U10F.V18(IO_L14P_T2_SRCC_14)
DDC_SDA_PD: U10F.F20(IO_L18N_T2_16)
DDC_SDA_PU: U10F.G20(IO_L8N_T1_AD10N_15)
DDR3_A0: U10F.U6(IO_L16P_T2_34)
DDR3_A1: U10F.V4(IO_L12P_T1_MRCC_34)
DDR3_A2: U10F.W5(IO_L15N_T2_DQS_34)
DDR3_A3: U10F.V5(IO_L16N_T2_34)
DDR3_A4: U10F.AA1(IO_L7P_T1_34)
DDR3_A5: U10F.Y2(IO_L4N_T0_34)
DDR3_A6: U10F.AB1(IO_L7N_T1_34)
DDR3_A7: U10F.AB3(IO_L8P_T1_34)
DDR3_A8: U10F.AB2(IO_L8N_T1_34)
DDR3_A9: U10F.Y3(IO_L9P_T1_DQS_34)
DDR3_A10: U10F.W6(IO_L15P_T2_DQS_34)
DDR3_A11: U10F.Y1(IO_L5N_T0_34)
DDR3_A12: U10F.V2(IO_L2N_T0_34)
DDR3_A13: U10F.AA3(IO_L9N_T1_DQS_34)
DDR3_BA0: U10F.U5(IO_L14N_T2_SRCC_34)
DDR3_BA1: U10F.W4(IO_L12N_T1_MRCC_34)
DDR3_BA2: U10F.V7(IO_L19P_T3_34)
DDR3_CAS_N: U10F.Y7(IO_L23N_T3_34)
DDR3_CK_N: U10F.R2(IO_L3N_T0_DQS_34)
DDR3_CK_P: U10F.R3(IO_L3P_T0_DQS_34)
DDR3_CKE: U10F.Y8(IO_L23P_T3_34)
DDR3_CS0_N: U10F.V9(IO_L21P_T3_DQS_34)
DDR3_DM0: U10F.G1(IO_L5P_T0_AD13P_35)
DDR3_DM1: U10F.H4(IO_L12P_T1_MRCC_35)
DDR3_DM2: U10F.M5(IO_L23N_T3_35)
DDR3_DM3: U10F.L3(IO_L14P_T2_SRCC_35)
DDR3_DQ0: U10F.C2(IO_L2P_T0_AD12P_35)
DDR3_DQ1: U10F.F1(IO_L5N_T0_AD13N_35)
DDR3_DQ2: U10F.B1(IO_L1P_T0_AD4P_35)
DDR3_DQ3: U10F.F3(IO_L6P_T0_35)
DDR3_DQ4: U10F.A1(IO_L1N_T0_AD4N_35)
DDR3_DQ5: U10F.D2(IO_L4N_T0_35)
DDR3_DQ6: U10F.B2(IO_L2N_T0_AD12N_35)
DDR3_DQ7: U10F.E2(IO_L4P_T0_35)
DDR3_DQ8: U10F.J5(IO_L10P_T1_AD15P_35)
DDR3_DQ9: U10F.H3(IO_L11P_T1_SRCC_35)
DDR3_DQ10: U10F.K1(IO_L7P_T1_AD6P_35)
DDR3_DQ11: U10F.H2(IO_L8P_T1_AD14P_35)
DDR3_DQ12: U10F.J1(IO_L7N_T1_AD6N_35)
DDR3_DQ13: U10F.G2(IO_L8N_T1_AD14N_35)
DDR3_DQ14: U10F.H5(IO_L10N_T1_AD15N_35)
DDR3_DQ15: U10F.G3(IO_L11N_T1_SRCC_35)
DDR3_DQ16: U10F.N2(IO_L22N_T3_35)
DDR3_DQ17: U10F.M6(IO_L23P_T3_35)
DDR3_DQ18: U10F.P1(IO_L20N_T3_35)
DDR3_DQ19: U10F.N5(IO_L24N_T3_35)
DDR3_DQ20: U10F.P2(IO_L22P_T3_35)
DDR3_DQ21: U10F.N4(IO_L19P_T3_35)
DDR3_DQ22: U10F.R1(IO_L20P_T3_35)
DDR3_DQ23: U10F.P6(IO_L24P_T3_35)
DDR3_DQ24: U10F.K3(IO_L14N_T2_SRCC_35)
DDR3_DQ25: U10F.M2(IO_L16N_T2_35)
DDR3_DQ26: U10F.K4(IO_L13P_T2_MRCC_35)
DDR3_DQ27: U10F.M3(IO_L16P_T2_35)
DDR3_DQ28: U10F.J6(IO_L17N_T2_35)
DDR3_DQ29: U10F.L5(IO_L18P_T2_35)
DDR3_DQ30: U10F.J4(IO_L13N_T2_MRCC_35)
DDR3_DQ31: U10F.K6(IO_L17P_T2_35)
DDR3_DQS0_N: U10F.D1(IO_L3N_T0_DQS_AD5N_35)
DDR3_DQS0_P: U10F.E1(IO_L3P_T0_DQS_AD5P_35)
DDR3_DQS1_N: U10F.J2(IO_L9N_T1_DQS_AD7N_35)
DDR3_DQS1_P: U10F.K2(IO_L9P_T1_DQS_AD7P_35)
DDR3_DQS2_N: U10F.P4(IO_L21N_T3_DQS_35)
DDR3_DQS2_P: U10F.P5(IO_L21P_T3_DQS_35)
DDR3_DQS3_N: U10F.L1(IO_L15N_T2_DQS_35)
DDR3_DQS3_P: U10F.M1(IO_L15P_T2_DQS_35)
DDR3_ODT0: U10F.W9(IO_L24P_T3_34)
DDR3_RAS_N: U10F.Y9(IO_L24N_T3_34)
DDR3_RESET_N: U10F.AB5(IO_L10N_T1_34)
DDR3_WE_N: U10F.V8(IO_L21N_T3_DQS_34)
FPGA_DONE: R14F.1 U10F.G11(DONE_0)
FPGA_INIT: R13F.1 U10F.U12(INIT_B_0)
FPGA_LED0: R18F.2 U10F.M21(IO_L10P_T1_AD11P_15)
FPGA_LED1: R17F.2 U10F.N20(IO_L18P_T2_A24_15)
FPGA_LED2: R16F.2 U10F.L21(IO_L10N_T1_AD11N_15)
FPGA_MODE: P10F.1 R15F.2 U10F.U9(M2_0)
FPGA_PROGRAM_B: R12F.1 U10F.N12(PROGRAM_B_0)
FPGA_PUDC: R10F.1 U10F.U22(IO_L3P_T0_DQS_PUDC_B_14)
FPGA_SPI_CS: U10F.T19(IO_L6P_T0_FCS_B_14)
FPGA_SPI_MISO_D1: U10F.R22(IO_L1N_T0_D01_DIN_14)
FPGA_SPI_MOSI_D0: U10F.P22(IO_L1P_T0_D00_MOSI_14)
FPGA_SPI_RES_D3: U10F.R21(IO_L2N_T0_D03_14)
FPGA_SPI_SCK: U10F.L12(CCLK_0)
FPGA_SPI_WP_D2: U10F.P21(IO_L2P_T0_D02_14)
FPGA_TCK: U10F.V12(TCK_0)
FPGA_TDI: U10F.R13(TDI_0)
FPGA_TDO: U10F.U13(TDO_0)
FPGA_TMS: U10F.T13(TMS_0)
FUSB_N: U10F.C15(IO_L3N_T0_DQS_16)
FUSB_P: U10F.C14(IO_L3P_T0_DQS_16)
HAX_0: U10F.B15(IO_L7P_T1_16)
HAX_1: U10F.B16(IO_L7N_T1_16)
HAX_2: U10F.B13(IO_L8N_T1_16)
HAX_3: U10F.A15(IO_L9P_T1_DQS_16)
HAX_4: U10F.A16(IO_L9N_T1_DQS_16)
HAX_5: U10F.A13(IO_L10P_T1_16)
HAX_6: U10F.A14(IO_L10N_T1_16)
HAX_7: U10F.B17(IO_L11P_T1_SRCC_16)
HAX_8: U10F.B18(IO_L11N_T1_SRCC_16)
HAX_9: U10F.C17(IO_L12N_T1_MRCC_16)
HAX_10: U10F.C18(IO_L13P_T2_MRCC_16)
HAX_11: U10F.C19(IO_L13N_T2_MRCC_16)
HAX_12: U10F.B20(IO_L16P_T2_16)
HAX_13: U10F.A20(IO_L16N_T2_16)
HAX_14: U10F.A18(IO_L17P_T2_16)
HAX_15: U10F.A19(IO_L17N_T2_16)
HAX_CLK_N: U10F.E6(MGTREFCLK0N_216)
HAX_CLK_P: U10F.F6(MGTREFCLK0P_216)
HDMI_HPD_LL_N: U10F.U17(IO_L18P_T2_A12_D28_14)
I2C0_SCL: U10F.F13(IO_L1P_T0_16)
I2C0_SDA: U10F.F14(IO_L1N_T0_16)
MCU_INT0: U10F.D15(IO_L6N_T0_VREF_16)
MCU_INT1: U10F.G13(IO_L1N_T0_AD0N_15)
OV0_CEC_R: U10F.P19(IO_L5P_T0_D06_14)
OV0_DDC_SCL_LV: U10F.W17(IO_L16N_T2_A15_D31_14)
OV0_DDC_SDA_LV: U10F.R17(IO_L24N_T3_A00_D16_14)
OV0_HDMI_HPD_LV: U10F.V17(IO_L16P_T2_CSI_B_14)
OV0_TMDS0_N: U10F.AB18(IO_L17N_T2_A13_D29_14)
OV0_TMDS0_P: U10F.AA18(IO_L17P_T2_A14_D30_14)
OV0_TMDS1_N: U10F.AA19(IO_L15P_T2_DQS_RDWR_B_14)
OV0_TMDS1_P: U10F.AB20(IO_L15N_T2_DQS_DOUT_CSO_B_14)
OV0_TMDS2_N: U10F.AB21(IO_L10P_T1_D14_14)
OV0_TMDS2_P: U10F.AB22(IO_L10N_T1_D15_14)
OV0_TMDS3_N: U10F.Y18(IO_L13P_T2_MRCC_14)
OV0_TMDS3_P: U10F.Y19(IO_L13N_T2_MRCC_14)
PCICLK_N: C23F.1 U10F.E10(MGTREFCLK1N_216)
PCICLK_P: C21F.1 U10F.F10(MGTREFCLK1P_216)
PER0_N: C25F.1
PER0_P: C24F.1
PER1_N: C36F.1
PER1_P: C27F.1
PER2_N: C40F.1
PER2_P: C37F.1
PER3_N: C22F.1
PER3_P: C20F.1
PERC0_N: C25F.2 U10F.C5(MGTPTXN1_216)
PERC0_P: C24F.2 U10F.D5(MGTPTXP1_216)
PERC1_N: C36F.2 U10F.A6(MGTPTXN2_216)
PERC1_P: C27F.2 U10F.B6(MGTPTXP2_216)
PERC2_N: C40F.2 U10F.C7(MGTPTXN3_216)
PERC2_P: C37F.2 U10F.D7(MGTPTXP3_216)
PERC3_N: C22F.2 U10F.A4(MGTPTXN0_216)
PERC3_P: C20F.2 U10F.B4(MGTPTXP0_216)
PERST#: U10F.E18(IO_L15N_T2_DQS_16)
PET0_N: U10F.C11(MGTPRXN1_216)
PET0_P: U10F.D11(MGTPRXP1_216)
PET1_N: U10F.A10(MGTPRXN2_216)
PET1_P: U10F.B10(MGTPRXP2_216)
PET2_N: U10F.C9(MGTPRXN3_216)
PET2_P: U10F.D9(MGTPRXP3_216)
PET3_N: U10F.A8(MGTPRXN0_216)
PET3_P: U10F.B8(MGTPRXP0_216)
REFCLK_N: C23F.2
REFCLK_P: C21F.2
RX0_FORCEPLUG: U10F.N22(IO_L15P_T2_DQS_15)
RX0_FORCEUNPLUG: U10F.M22(IO_L15N_T2_DQS_ADV_B_15)
RX0_TMDS0_N: U10F.K21(IO_L9P_T1_DQS_AD3P_15)
RX0_TMDS0_P: U10F.K22(IO_L9N_T1_DQS_AD3N_15)
RX0_TMDS1_N: U10F.J20(IO_L11P_T1_SRCC_15)
RX0_TMDS1_P: U10F.J21(IO_L11N_T1_SRCC_15)
RX0_TMDS2_N: U10F.J22(IO_L7P_T1_AD2P_15)
RX0_TMDS2_P: U10F.H22(IO_L7N_T1_AD2N_15)
RX0_TMDS3_N: U10F.L19(IO_L14P_T2_SRCC_15)
RX0_TMDS3_P: U10F.L20(IO_L14N_T2_SRCC_15)
SMCLK: U10F.D19(IO_L14N_T2_SRCC_16)
SMDAT: U10F.D20(IO_L19P_T3_16)
SYSCLK: U10F.J19(IO_L12P_T1_MRCC_15) U11F.3(OUT)
TX0_TMDS0_N: U10F.W22(IO_L7N_T1_D10_14)
TX0_TMDS0_P: U10F.W21(IO_L7P_T1_D09_14)
TX0_TMDS1_N: U10F.V20(IO_L11N_T1_SRCC_14)
TX0_TMDS1_P: U10F.U20(IO_L11P_T1_SRCC_14)
TX0_TMDS2_N: U10F.U21(IO_L4N_T0_D05_14)
TX0_TMDS2_P: U10F.T21(IO_L4P_T0_D04_14)
TX0_TMDS3_N: U10F.W19(IO_L12P_T1_MRCC_14)
TX0_TMDS3_P: U10F.W20(IO_L12N_T1_MRCC_14)
TX1_CEC: U10F.P17(IO_L21N_T3_DQS_A06_D22_14)
TX1_CLK_N: U10F.G21(IO_L24P_T3_16)
TX1_CLK_P: U10F.G22(IO_L24N_T3_16)
TX1_HPD_LL: U10F.U18(IO_L18N_T2_A11_D27_14)
TX1_SCL_LV: U10F.P16(IO_L24P_T3_A01_D17_14)
TX1_SDA_LV: U10F.R16(IO_L22N_T3_A04_D20_14)
TX1_TMDS0_N: U10F.E22(IO_L22P_T3_16)
TX1_TMDS0_P: U10F.D22(IO_L22N_T3_16)
TX1_TMDS1_N: U10F.C22(IO_L20P_T3_16)
TX1_TMDS1_P: U10F.B22(IO_L20N_T3_16)
TX1_TMDS2_N: U10F.B21(IO_L21P_T3_DQS_16)
TX1_TMDS2_P: U10F.A21(IO_L21N_T3_DQS_16)
UART0_RX: U10F.E13(IO_L4P_T0_16)
UART0_TX: U10F.E14(IO_L4N_T0_16)
WAKE#: U10F.E19(IO_L14P_T2_SRCC_16)
NetD10F_1: D10F.1(A) R16F.1
NetD11F_1: D11F.1(A) R17F.1
NetD12F_1: D12F.1(A) R18F.1
NetR11F_1: R11F.1 U10F.F8(MGTRREF_216)

Not connected (* = marked no-connect by the designer): U10F AA4(IO_L11N_T1_SRCC_34) AA5(IO_L10P_T1_34) AA6(IO_L18N_T2_34) AA8(IO_L22P_T3_34) AA9(NC) AA10(NC) AA11(NC) AA13(NC) AA14(NC) AA15(NC) AA16(NC) AA20(IO_L8P_T1_D11_14) AA21(IO_L8N_T1_D12_14) AB6(IO_L20N_T3_34) AB7(IO_L20P_T3_34) AB8(IO_L22N_T3_34) AB10(NC) AB11(NC) AB12(NC) AB13(NC) AB15(NC) AB16(NC) AB17(NC) C13(IO_L8P_T1_16) C20(IO_L19N_T3_VREF_16) D14(IO_L6P_T0_16) D16(IO_L5N_T0_16) D17(IO_L12P_T1_MRCC_16) D21(IO_L23N_T3_16) E16(IO_L5P_T0_16) E17(IO_L2N_T0_16) E21(IO_L23P_T3_16) F4(IO_0_35) F15(IO_0_16) F16(IO_L2P_T0_16) F18(IO_L15P_T2_DQS_16) F19(IO_L18P_T2_16) F21(IO_25_16) G4(IO_L12N_T1_MRCC_35) G15(IO_L2P_T0_AD8P_15) G16(IO_L2N_T0_AD8N_15) G17(IO_L4P_T0_15) G18(IO_L4N_T0_15) H13(IO_L1P_T0_AD0P_15) H14(IO_L3N_T0_DQS_AD1N_15) H15(IO_L5N_T0_AD9N_15) H17(IO_L6P_T0_15) H18(IO_L6N_T0_VREF_15) H19(IO_L12N_T1_MRCC_15) H20(IO_L8P_T1_AD10P_15) J14(IO_L3P_T0_DQS_AD1P_15) J15(IO_L5P_T0_AD9P_15) J16(IO_0_15) J17(IO_L21N_T3_DQS_A18_15) K13(IO_L19P_T3_A22_15) K14(IO_L19N_T3_A21_VREF_15) K16(IO_L23N_T3_FWE_B_15) K17(IO_L21P_T3_DQS_15) K18(IO_L13P_T2_MRCC_15) K19(IO_L13N_T2_MRCC_15) L4(IO_L18N_T2_35) L6(IO_25_35) L13(IO_L20N_T3_A19_15) L14(IO_L22P_T3_A17_15) L15(IO_L22N_T3_A16_15) L16(IO_L23P_T3_FOE_B_15) L18(IO_L16N_T2_A27_15) M13(IO_L20P_T3_A20_15) M15(IO_L24P_T3_RS1_15) M16(IO_L24N_T3_RS0_15) M17(IO_25_15) M18(IO_L16P_T2_A28_15) M20(IO_L18N_T2_A23_15) N13(IO_L23P_T3_A03_D19_14) N14(IO_L23N_T3_A02_D18_14) N15(IO_25_14) N17(IO_L21P_T3_DQS_14) N18(IO_L17P_T2_A26_15) N19(IO_L17N_T2_A25_15) P14(IO_L19P_T3_A10_D26_14) P15(IO_L22P_T3_A05_D21_14) R4(IO_L13P_T2_MRCC_34) R6(IO_L17P_T2_34) R14(IO_L19N_T3_A09_D25_VREF_14) R18(IO_L20P_T3_A08_D24_14) R19(IO_L5N_T0_D07_14) T1(IO_L1P_T0_34) T3(IO_0_34) T4(IO_L13N_T2_MRCC_34) T5(IO_L14P_T2_SRCC_34) T6(IO_L17N_T2_34) T14(NC) T15(NC) T16(NC) T20(IO_L6N_T0_D08_VREF_14) U1(IO_L1N_T0_34) U2(IO_L2P_T0_34) U3(IO_L6P_T0_34) U7(IO_25_34) U15(NC) U16(NC) V10(NC) V13(NC) V14(NC) V15(NC) V19(IO_L14N_T2_SRCC_14) V22(IO_L3N_T0_DQS_EMCCLK_14) W1(IO_L5P_T0_34) W2(IO_L4P_T0_34) W10(NC) W11(NC) W12(NC) W14(NC) W15(NC) W16(NC) Y4(IO_L11P_T1_SRCC_34) Y6(IO_L18P_T2_34) Y11(NC) Y12(NC) Y13(NC) Y14(NC) Y16(NC) Y17(NC) Y21(IO_L9P_T1_DQS_14) Y22(IO_L9N_T1_DQS_D13_14)

## Layout directives
differential pair: DDR3_CK_N, DDR3_CK_P, DDR3_DQS0_N, DDR3_DQS0_P, DDR3_DQS1_N, DDR3_DQS1_P, DDR3_DQS2_N, DDR3_DQS2_P, DDR3_DQS3_N, DDR3_DQS3_P, HAX_CLK_N, HAX_CLK_P, PCICLK_N, PCICLK_P, PER0_N, PER0_P, PER1_N, PER1_P, PER2_N, PER2_P, PER3_N, PER3_P, PERC0_N, PERC0_P, PERC1_N, PERC1_P, PERC2_N, PERC2_P, PERC3_N, PERC3_P, PET0_N, PET0_P, PET1_N, PET1_P, PET2_N, PET2_P, PET3_N, PET3_P, REFCLK_N, REFCLK_P
net class PCIE_DAT: PER0_N, PER0_P, PER1_N, PER1_P, PER2_N, PER2_P, PER3_N, PER3_P, PERC0_N, PERC0_P, PERC1_N, PERC1_P, PERC2_N, PERC2_P, PERC3_N, PERC3_P, PET0_N, PET0_P, PET1_N, PET1_P, PET2_N, PET2_P, PET3_N, PET3_P
net class PCIE_CLK: HAX_CLK_N, HAX_CLK_P, PCICLK_N, PCICLK_P, REFCLK_N, REFCLK_P

## Notes on the sheet
- HDMI/CFG/AUX
- HDMI/AUX
- HAX IO
- DDR3
- inversion
- (near U10F) connect extra bank 13 to VCCO_13 improve ESD
- Config I/O voltage = 3.3V

## Library data of the parts
C10F C17F C28F C29F C38F C46F C47F C48F C56F C57F C58F C63F C64F C65F C70F C71F C72F C77F C78F C79F C84F C85F C86F = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL05A475MQ5NQNC; VENDOR: Samsung; MYPN: C-475-6p3-X5R-0402
C11F C12F C15F C16F C20F C21F C22F C23F C24F C25F C27F C36F C37F C40F C87F C88F C89F = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A104KQ3NNNC; VENDOR: Samsung; MYPN: C-104-6p3-X5R-0201
C13F C14F C18F C19F C26F C30F C31F C32F C33F C34F C39F C41F C42F C43F C44F C45F C51F C52F C53F C54F C55F C59F C60F C61F C62F C66F C67F C68F C69F C73F C74F C75F C76F C80F C81F C82F C83F = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A474KQ3NNNH; VENDOR: Samsung; MYPN: C-474-6p3-X5R-0201
C35F C49F C50F = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL31A107MQHNNNE; VENDOR: Samsung; MYPN: C-107-6p3-X5R-1206
D10F D11F D12F = LED2: Typical RED, GREEN, YELLOW, AMBER GaAs LED; MPN: CB-2012QWC-P8; VENDOR: CITYBRIGHT; MYPN: D-LED-WHITE1-0805
P10F = Header 2: Header, 2-Pin
R10F = Res1: Resistor; MPN: RS02U102FT; VENDOR: Fenghua; MYPN: R-102-1P-1_16W-0402
R11F = Res1: Resistor; VENDOR: ANY; MYPN: R-101-1P-1_16W-0402
R12F R13F = Res1: Resistor; VENDOR: ANY; MYPN: R-472-1P-1_16W-0402
R14F = Res1: Resistor; MPN: RS02U331FT; VENDOR: Fenghua; MYPN: R-331-1P-1_16W-0402
R15F = Res1: Resistor; VENDOR: ANY; MYPN: R-102-1P-1_16W-0402
R16F R17F R18F = Res1: Resistor; MPN: RS02U101FT; VENDOR: Fenghua; MYPN: R-101-1P-1_16W-0402
U10F = XC7A35T-2FGG484C: Artix-7 FPGA, 250 User I/Os, 4 GTP, 484-Ball BGA, Speed Grade 2, Commercial Grade, Pb-Free; Manufacturer: Xilinx; Total Block RAM: 1800 Kb; GTP: 4; Clock Mgmt Tiles (CMTs): 5; Logic Cells: 33280; Available User I/O: 250; Speed Grades: 2; MYPN: U-XC7A35T-2FGG484C
U11F = OSCILLATOR: Abracon ASDMB Miniature Oscillator; MPN: ASDMB-50.000MHZ-LC-T; VENDOR: Abracon LLC; MYPN: U-ASDMB-50MHz
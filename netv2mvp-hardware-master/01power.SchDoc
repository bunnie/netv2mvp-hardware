# Altium schematic sheet 01power.SchDoc
size B

## Parts
C10P  10uF, 6.3V, X5R  [CAPC1608N]
C11P  10nF, 25V, X7R  [CAPC1005N]
C12P  10uF, 6.3V, X5R  [CAPC1608N]
C13P  10nF, 25V, X7R  [CAPC1005N]
C14P  10uF, 6.3V, X5R  [CAPC1608N]
C15P  10uF, 6.3V, X5R  [CAPC1608N]
C16P  10uF, 6.3V, X5R  [CAPC1608N]
C17P  10uF, 6.3V, X5R  [CAPC1608N]
C18P  10uF, 6.3V, X5R  [CAPC1608N]
C19P  10nF, 25V, X7R  [CAPC1005N]
C20P  10uF, 6.3V, X5R  [CAPC1608N]
C21P  10nF, 25V, X7R  [CAPC1005N]
C22P  10uF, 6.3V, X5R  [CAPC1608N]
C23P  10uF, 6.3V, X5R  [CAPC1608N]
C24P  10uF, 6.3V, X5R  [CAPC1608N]
C25P  10uF, 6.3V, X5R  [CAPC1608N]
C26P  1.0uF, 6.3V, X5R  [CAPC0603X03L]
C27P  1.0uF, 6.3V, X5R  [CAPC0603X03L]
C28P  0.1uF, 50V, X7R  [CAPC2012N]
C29P  10uF, 6.3V, X5R  [CAPC1608N]
C30P  10uF, 6.3V, X5R  [CAPC1608N]
C31P  0.22uF, 6.3V, X5R  [CAPC0603X03L]
C32P  10uF, 50V, X7R  [CAPC3216N]
C33P  0.1uF, 50V, X7R  [CAPC2012N]
C34P  22uF, 25V, X5R  [CAPC3216N]
C35P  22uF, 25V, X5R  [CAPC3216N]
C37P  0.1uF, 6.3V, X5R  [CAPC0603X03L]
C38P  0.1uF, 50V, X7R  [CAPC2012N]
C39P  75pF, 50V, NP0  [CAPC1005N]
D10P  PESD24VL1BA  [SOD-323]
D11P  white LED  [CD2012-0805]
JP10P  2.1mm x 5.5mm DC jack  [CUI_PJ_002AH_SMT]
L10P  0.56uH LPS3008-561MRC  [COILCRAFT_LPS3008]
L11P  0.56uH LPS3008-561MRC  [COILCRAFT_LPS3008]
L12P  0.56uH LPS3008-561MRC  [COILCRAFT_LPS3008]
L13P  0.56uH LPS3008-561MRC  [COILCRAFT_LPS3008]
L14P  22uH MSS1038-223ML  [COILCRAFT_MSS1038]
NT10P  12W, 12V power supply with 2.1mm x 5.5mm plug
R10P  0 ohm  [RESC1608N]
R11P  0 ohm  [RESC1608N]
R12P  100k, 1%  [RESC1005N]
R13P  100k, 1%  [RESC1005N]
R14P  100k, 1%  [RESC1005N]
R15P  100k, 1%  [RESC1005N]
R16P  402k, 1%  [RESC1005N]
R17P  80.6k, 1%  [RESC1005N]
R18P  0 ohm  [RESC1608N]
R19P  0 ohm  [RESC1608N]
R20P  0 ohm  [RESC1608N]
R21P  100k, 1%  [RESC1005N]
R22P  100k, 1%  [RESC1005N]
R23P  100k, 1%  [RESC1005N]
R24P  100k, 1%  [RESC1005N]
R25P  115k, 1%  [RESC1005N]
R26P  31.6k, 1%  [RESC1005N]
R27P  0 ohm  [RESC1608N]
R28P  0 ohm (DNP)  [RESC1608N]
R29P  49.9, 1%  [RESC1005N]
R30P  100k, 1%  [RESC1005N]
R31P  13.3k, 1%  [RESC1005N]
R32P  330, 1%  [RESC1005N]
U10P  FAN53541UCX  [BGA20C40P4X5_156X196X62]
U11P  FAN53541UCX  [BGA20C40P4X5_156X196X62]
U12P  FAN53541UCX  [BGA20C40P4X5_156X196X62]
U13P  FAN53541UCX  [BGA20C40P4X5_156X196X62]
U14P  LP5907UVX-1.2/NOPB  [TI_YKE004]
U15P  TPS51206  [TI-DSQ-R-PWSON-N10]
U16P  TPS54202  [SOT26A-6N]

## Nets
GND: C10P.2 C11P.2 C12P.2 C13P.2 C14P.2 C15P.2 C16P.2 C17P.2 C18P.2 C19P.2 C20P.2 C21P.2 C22P.2 C23P.2 C24P.2 C25P.2 C26P.2 C27P.2 C29P.2 C30P.2 C31P.2 C32P.1 C33P.2 C34P.1 C35P.1 C37P.2 C38P.2 D10P.2(K) JP10P.2 JP10P.3 R16P.2 R17P.2 R25P.2 R26P.2 R31P.1 R32P.1 U10P.B1(MODE) U10P.B2(GND) U10P.B3(GND) U10P.B4(AGND) U10P.C1(GND) U10P.C2(GND) U10P.C3(GND) U10P.C4(GND) U11P.B1(MODE) U11P.B2(GND) U11P.B3(GND) U11P.B4(AGND) U11P.C1(GND) U11P.C2(GND) U11P.C3(GND) U11P.C4(GND) U12P.B1(MODE) U12P.B2(GND) U12P.B3(GND) U12P.B4(AGND) U12P.C1(GND) U12P.C2(GND) U12P.C3(GND) U12P.C4(GND) U13P.B1(MODE) U13P.B2(GND) U13P.B3(GND) U13P.B4(AGND) U13P.C1(GND) U13P.C2(GND) U13P.C3(GND) U13P.C4(GND) U14P.B2(GND) U15P.4(PGND) U15P.8(GND) U15P.11(GND) U16P.1(GND)
P1.0V: C14P.1 C15P.1 L10P.2 R14P.2 U10P.A4(VOUT)
P1.2VTT: C27P.1 U14P.A2(OUT)
P1.5V_D: C22P.1 C23P.1 L12P.2 R23P.2 R27P.2 U12P.A4(VOUT) U15P.1(VDDQSNS)
P1.8V: C16P.1 C17P.1 L11P.2 R15P.2 U11P.A4(VOUT)
P3.3V: C24P.1 C25P.1 C37P.1 L13P.2 R20P.2 R24P.2 U13P.A4(VOUT) U15P.10(VDD)
P5.0V: C34P.2 C35P.2 D11P.1(A) L14P.2 R10P.1 R11P.1 R18P.1 R19P.1 R22P.2 R28P.1 R29P.2
P12V: C32P.2 C33P.1 C38P.1 D10P.1(A) JP10P.1 U16P.3(VIN)
VTT: C30P.1 U15P.3(VTT) U15P.5(VTTSNS)
VTT_REF: C31P.1 U15P.6(VTTREF)
VUSB: R28P.2
FB_P1.0V: R14P.1 R16P.1 U10P.A3(FB)
FB_P1.5V: R23P.1 R25P.1 U12P.A3(FB)
FB_P1.8V: R15P.1 R17P.1 U11P.A3(FB)
FB_P3.3V: R24P.1 R26P.1 U13P.A3(FB)
FB_P5.0V: C39P.2 R30P.1 R31P.2 U16P.4(FB)
P3V_MTT: C26P.1 R20P.1 U14P.A1(IN)
P3V_VTT: C29P.1 R27P.1 U15P.2(VLDOIN)
P5V_1: C10P.1 C11P.1 R10P.2 R12P.2 U10P.A2(EN) U10P.D1(VIN) U10P.D2(VIN) U10P.E1(VIN) U10P.E2(VIN)
P5V_1.5: C18P.1 C19P.1 R18P.2 R21P.1 U12P.D1(VIN) U12P.D2(VIN) U12P.E1(VIN) U12P.E2(VIN)
P5V_1.8: C12P.1 C13P.1 R11P.2 R13P.2 U11P.D1(VIN) U11P.D2(VIN) U11P.E1(VIN) U11P.E2(VIN)
P5V_3.3: C20P.1 C21P.1 R19P.2 U13P.D1(VIN) U13P.D2(VIN) U13P.E1(VIN) U13P.E2(VIN)
PGOOD_P1.0V: R12P.1 U10P.A1(PGOOD) U11P.A2(EN)
PGOOD_P1.8V: R13P.1 U11P.A1(PGOOD) U12P.A2(EN) U13P.A2(EN) U14P.B1(EN) U15P.7(S3) U15P.9(S5)
SW1.0: L10P.1 U10P.D3(SW) U10P.D4(SW) U10P.E3(SW) U10P.E4(SW)
SW1.5: L12P.1 U12P.D3(SW) U12P.D4(SW) U12P.E3(SW) U12P.E4(SW)
SW1.8: L11P.1 U11P.D3(SW) U11P.D4(SW) U11P.E3(SW) U11P.E4(SW)
SW3.3: L13P.1 U13P.D3(SW) U13P.D4(SW) U13P.E3(SW) U13P.E4(SW)
SW5.0: C28P.1 L14P.1 U16P.2(SW)
NetC28P_2: C28P.2 U16P.6(BOOT)
NetC39P_1: C39P.1 R29P.1 R30P.2
NetD11P_2: D11P.2(K) R32P.2
NetR21P_2: R21P.2 U12P.A1(PGOOD)
NetR22P_1: R22P.1 U13P.A1(PGOOD)

Not connected (* = marked no-connect by the designer): U16P 5(EN)*

## Notes on the sheet
- (near C11P) first on
- 2nd up
- (near R16P) 1.00V
- (near R17P) 1.79V
- Power-on domain #1 - VCCINT/VCCBRAM
- Power-on domain #2 - VCCAUX
- Power-on domain #3 - VCCO
- last up
- not used
- (near R25P) 1.50V
- (near R26P) 3.33V
- Read UG482 for guidelines on decaps for Artix FPGA
- (near L14P) Master down regulator - 5V allows lower-I switcher to be used
- (near L14P) Irms max = 2A
- (near L14P) Ipeak = 2.17A
- (near L14P) For 5V @ 2A, 12V input:
- Will work with ~6-18V range
- (near D10P) Warning: this device has a polarity, need to update symbol!
- Copyright 2017 Andrew "bunnie" Huang
- Licensed under CERN OHL v1.2 or later

## Library data of the parts
C10P C12P C14P C15P C16P C17P C18P C20P C22P C23P C24P C25P C29P C30P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL10A106MQ8NNNC; VENDOR: Samsung; MYPN: C-106-6.3-X5R-0603
C11P C13P C19P C21P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL05B103KA5NNNC; VENDOR: Samsung; MYPN: C-103-25-X7R-0402
C26P C27P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A105KQ3CSNC; VENDOR: Samsung; MYPN: C-105-6p3-X5R-0201
C28P C33P C38P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL21B104KBCNNWC; VENDOR: Samsung; MYPN: C-104-50-X7R-0805
C31P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A224MQ3NNNC; VENDOR: Samsung; MYPN: C-224-6p3-X5R-0201
C32P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL31A106KBHNNNE; VENDOR: Samsung; MYPN: C-106-50-X5R-1206
C34P C35P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL31A226KAHNNNE; VENDOR: Samsung; MYPN: C-226-25-X5R-1206
C37P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL03A104KQ3NNNC; VENDOR: Samsung; MYPN: C-104-6p3-X5R-0201
C39P = Cap Semi: Capacitor (Semiconductor SIM Model); MPN: CL05C750JB5NNNC; VENDOR: Samsung; MYPN: C-750-50-NP0-0402
D10P = BIDIR_ESD: Bidirectional zener diode, Vz 17.1V nom; MPN: PESD24VL1BA,115; MYPN: U-PESD24VL1BA,115; VENDOR: NXP
D11P = LED2: Typical RED, GREEN, YELLOW, AMBER GaAs LED; MPN: CB-2012QWC-P8; VENDOR: CITYBRIGHT; MYPN: D-LED-WHITE1-0805
JP10P = PWR2.5: Low Voltage Power Supply Connector; MPN: PJ-002AH-SMT-TR; MYPN: J-PJ-002AH-SMT-TR; VENDOR: CUI Inc
L10P L11P L12P L13P = Inductor Iron: Magnetic-Core Inductor; VENDOR: COILCRAFT; MYPN: L-LPS3008-561MR
L14P = Inductor Iron: Magnetic-Core Inductor; MPN: MSS1038-223MLB; VENDOR: COILCRAFT; MYPN: L-MSS1038-223MLB
NT10P = NOTE: Placeholder for non-board BOM items; MPN: ANY; MYPN: NT-ACDC-12W-12V-P2.1
R10P R11P R18P R19P R20P R27P = Res1: Resistor; VENDOR: ANY; MYPN: R-0R0-1P-1_16W-0603
R12P R13P R14P R15P R21P R22P R23P R24P R30P = Res1: Resistor; VENDOR: ANY; MYPN: R-104-1P-1_16W-0402
R16P = Res1: Resistor; VENDOR: ANY; MYPN: R-4023-1P-1_16W-0402
R17P = Res1: Resistor; VENDOR: ANY; MYPN: R-8062-1P-1_16W-0402
R25P = Res1: Resistor; VENDOR: ANY; MYPN: R-1153-1P-1_16W-0402
R26P = Res1: Resistor; VENDOR: ANY; MYPN: R-3162-1P-1_16W-0402
R28P = Res1: Resistor; VENDOR: ANY
R29P = Res1: Resistor; VENDOR: ANY; MYPN: R-49R9-1P-1_16W-0402
R31P = Res1: Resistor; VENDOR: ANY; MYPN: R-1332-1P-1_16W-0402
R32P = Res1: Resistor; MPN: RS02U331FT; VENDOR: Fenghua; MYPN: R-331-1P-1_16W-0402
U10P U11P U12P U13P = FAN53541UCX: 2.4MHz, 5A TinyBuck Synchronous Buck Regulator; MYPN: UFAN53541UCX; VENDOR: Fairchild Semiconductor
U14P = LP5907UVX: Ultra low-noise 250mA LDO for RF and analog in DSBGA; VENDOR: TI; MYPN: ULP5907UVX-1.2
U15P = TPS51206: 2A-peak sink/source DDR termination regulator; MPN: TPS51206DSQ(T/R); MYPN: UTPS51206DSQ; VENDOR: TI
U16P = TPS54202: 4.5 to 28V input, 2A output, step down sync buck; MPN: TPS54202DDCT; MYPN: U-TPS54202DDCT; VENDOR: TI